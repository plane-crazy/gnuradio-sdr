<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>taps_lpf</value></param>
<param><key>value</key><value>[1.3720911056225304e-06, 1.071107249117631e-06, 7.040755463094683e-07, 2.872369861961488e-07, -1.5999307834135834e-07, -6.159121426208003e-07, -1.0575678288660129e-06, -1.4618976820202079e-06, -1.8069151792587945e-06, -2.072881898129708e-06, -2.2434035145124653e-06, -2.3063942080625566e-06, -2.254845639981795e-06, -2.087366056002793e-06, -1.8084441535393125e-06, -1.42841849992692e-06, -9.631465900383773e-07, -4.333746801421512e-07, 1.3616090654977597e-07, 7.178708756327978e-07, 1.2826316151404171e-06, 1.8012269720202312e-06, 2.245840050818515e-06, 2.591520569694694e-06, 2.8175543320685392e-06, 2.9086543236189755e-06, 2.8559143174788915e-06, 2.6574625735520385e-06, 2.318777433174546e-06, 1.8526350231695687e-06, 1.2786815659637796e-06, 6.226417781363125e-07, -8.480726876314293e-08, -8.094500003608118e-07, -1.515168492005614e-06, -2.1657247089024168e-06, -2.726600541791413e-06, -3.166805072396528e-06, -3.4605543532961747e-06, -3.5887314879801124e-06, -3.540053739925497e-06, -3.3118687952082837e-06, -2.910537887146347e-06, -2.3513671294494998e-06, -1.658085693634348e-06, -8.618755487077578e-07, 2.7149318168432e-20, 8.859187232701515e-07, 1.751888817125291e-06, 2.5537140118103707e-06, 3.249227802371024e-06, 3.8004861835361226e-06, 4.175801677774871e-06, 4.351517873146804e-06, 4.313424597057747e-06, 4.057724254380446e-06, 3.5915018088417128e-06, 2.932656343546114e-06, 2.1092746465001255e-06, 1.1584795629460132e-06, 1.2478736266530177e-07, -9.419523507858685e-07, -1.9889384930138476e-06, -2.96301050184411e-06, -3.8133268844831036e-06, -4.493989763432182e-06, -4.9664881771605e-06, -5.201832209422719e-06, -5.182248060009442e-06, -4.902358796243789e-06, -4.369762336864369e-06, -3.6049675600224873e-06, -2.6406769393361174e-06, -1.520434580015717e-06, -2.9669553214262123e-07, 9.716046633911901e-07, 2.221864406237728e-06, 3.390883193787886e-06, 4.418033768160967e-06, 5.248376055533299e-06, 5.835563570144586e-06, 6.144379312900128e-06, 6.152769856271334e-06, 5.853268248756649e-06, 5.253707058727741e-06, 4.377180175652029e-06, 3.2612329050607514e-06, 1.956307414729963e-06, 5.234977606960456e-07, -9.682810286903987e-07, -2.445581003485131e-06, -3.834014023595955e-06, -5.061973752162885e-06, -6.064296030672267e-06, -6.7856844907510094e-06, -7.183709385572001e-06, -7.231227300508181e-06, -6.9180837272142526e-06, -6.251998001971515e-06, -5.258572855382226e-06, -3.980392648372799e-06, -2.4752587250986835e-06, -8.13615827155445e-07, 9.247138450518833e-07, 2.6543375497567467e-06, 4.288461695978185e-06, 5.743218025600072e-06, 6.941942046978511e-06, 7.819173333700746e-06, 8.324175723828375e-06, 8.42380632093409e-06, 8.104535481834318e-06, 7.373547759925714e-06, 6.258811936277198e-06, 4.808108769793762e-06, 3.0870455702824984e-06, 1.1761350151573424e-06, -8.329383263117052e-07, -2.8416864097380312e-06, -4.749618710775394e-06, -6.459241376433056e-06, -7.881008059484884e-06, -8.93797096068738e-06, -9.569893336447421e-06, -9.736605534271803e-06, -9.420424248673953e-06, -8.627490387880243e-06, -7.387930509139551e-06, -5.754829544457607e-06, -3.8020255033188732e-06, -1.6208155102503952e-06, 6.842709012744308e-07, 3.0004514428583207e-06, 5.2121790758974385e-06, 7.206877853604965e-06, 8.880638233677018e-06, 1.0143590770894662e-05, 1.0924682101176586e-05, 1.1175587133038789e-05, 1.087358032236807e-05, 1.0023149116022978e-05, 8.656304999021813e-06, 6.831486643932294e-06, 4.631153387890663e-06, 2.158102915927884e-06, -4.6928943220336805e-07, -3.1227009458234534e-06, -5.6700987443036865e-06, -7.982276656548493e-06, -9.93937919702148e-06, -1.1437066859798506e-05, -1.2392028111207765e-05, -1.2746539141517133e-05, -1.2471822628867812e-05, -1.157001588580897e-05, -1.0074636520585045e-05, -8.0494819485466e-06, -5.585981853073463e-06, -2.7991354727419093e-06, 1.7781452754661586e-07, 3.1997171845432604e-06, 6.11655605098349e-06, 8.780863026913721e-06, 1.1055138202209491e-05, 1.2818905815947801e-05, 1.3975037290947512e-05, 1.445502584829228e-05, 1.4222919162421022e-05, 1.3277694051794242e-05, 1.1653921319521032e-05, 9.42066890274873e-06, 6.678649697278161e-06, 3.5557497994886944e-06, 2.0110621790081495e-07, -3.2219727472693194e-06, -6.5439230638730805e-06, -9.597290045348927e-06, -1.222512946696952e-05, -1.4289034879766405e-05, -1.5676367183914408e-05, -1.6306328689097427e-05, -1.613453969184775e-05, -1.5155882465478498e-05, -1.3405420759227127e-05, -1.0957334779959638e-05, -7.921878932393156e-06, -4.4404819163901266e-06, -6.79212178056332e-07, 3.1791037145012524e-06, 6.943726475583389e-06, 1.0425402251712512e-05, 1.34458305183216e-05, 1.5846755559323356e-05, 1.7498199667898007e-05, 1.8305418052477762e-05, 1.8214215742773376e-05, 1.7214324543601833e-05, 1.5340629033744335e-05, 1.2672181583184283e-05, 9.32896182348486e-06, 5.466570655698888e-06, 1.2690413768723374e-06, -3.059888285861234e-06, -7.306618954316946e-06, -1.1258193808316719e-05, -1.4712933989358135e-05, -1.7490687241661362e-05, -1.944216273841448e-05, -2.0456875063246116e-05, -2.0469278751988895e-05, -1.946276461239904e-05, -1.747124406392686e-05, -1.4578290574718267e-05, -1.0913742698903661e-05, -6.64795197735657e-06, -1.983939682759228e-06, 2.852226771210553e-06, 7.6223432188271545e-06, 1.208776575367665e-05, 1.6021298506530002e-05, 1.92187144421041e-05, 2.150929685740266e-05, 2.2764859750168398e-05, 2.2906828235136345e-05, 2.1910902432864532e-05, 1.9809116565738805e-05, 1.6689109543222003e-05, 1.2690607036347501e-05, 7.999254194146488e-06, 2.8380684398143785e-06, -2.543119990150444e-06, -7.87970839155605e-06, -1.2905288713227492e-05, -1.7364909581374377e-05, -2.102794860547874e-05, -2.369998583162669e-05, -2.5233048290829174e-05, -2.553366357460618e-05, -2.4568362277932465e-05, -2.236623186036013e-05, -1.9018409147975035e-05, -1.4674459634989034e-05, -9.53579456108855e-06, -3.846408617391717e-06, 2.1186572212172905e-06, 8.066555892582983e-06, 1.3700967429031152e-05, 1.873681685538031e-05, 2.291464807058219e-05, 2.601392043288797e-05, 2.7864569347002544e-05, 2.8356236725812778e-05, 2.7444617444416508e-05, 2.5154649847536348e-05, 2.1580261091003194e-05, 1.688070551608689e-05, 1.1273565178271383e-05, 5.024763595429249e-06, -1.5639967614333727e-06, -8.169738975993823e-06, -1.4464001651504077e-05, -2.0129120457568206e-05, -2.4874205337255262e-05, -2.8450016543501988e-05, -3.066196586587466e-05, -3.138060128549114e-05, -3.0548970244126394e-05, -2.8186470444779843e-05, -2.4388995370827615e-05, -1.9325219909660518e-05, -1.3229222531663254e-05, -6.38975916444906e-06, 8.63355865021731e-07, 8.175096809281968e-06, 1.518255339760799e-05, 2.1532890968956053e-05, 2.6901067030848935e-05, 3.1006387871457264e-05, 3.362712959642522e-05, 3.461236337898299e-05, 3.3890464692376554e-05, 3.147378811263479e-05, 2.7459172997623682e-05, 2.2024330974090844e-05, 1.54200733959442e-05, 7.958842616062611e-06, -8.183177858798283e-19, -8.067427188507281e-06, -1.5843706933083013e-05, -2.2938149413676e-05, -2.8988690246478654e-05, -3.368028410477564e-05, -3.676124106277712e-05, -3.8056601624703035e-05, -3.74778792320285e-05, -3.502863910398446e-05, -3.080553869949654e-05, -2.499478250683751e-05, -1.7864056644611992e-05, -9.750277968123555e-06, -1.0437665878271218e-06, 7.830474714864977e-06, 1.643344876356423e-05, 2.4333823603228666e-05, 3.1129500712268054e-05, 3.6468009056989104e-05, 4.0064711356535554e-05, 4.1717838030308485e-05, 4.131963214604184e-05, 3.8862970541231334e-05, 3.4442986361682415e-05, 2.8253718483028933e-05, 2.057973324554041e-05, 1.1783139598264825e-05, 2.28660746870446e-06, -7.446901236107806e-06, -1.6936624888330698e-05, -2.5707699023769237e-05, -3.331484549562447e-05, -3.9364917029161006e-05, -4.3537136662052944e-05, -4.5599957957165316e-05, -4.542374881566502e-05, -4.2988565837731585e-05, -3.8386515370802954e-05, -3.1818632123759016e-05, -2.3586248062201776e-05, -1.4077308151172474e-05, -3.748159315364319e-06, 6.89827584210434e-06, 1.733692261041142e-05, 2.704638427530881e-05, 3.55349293386098e-05, 4.2365318222437054e-05, 4.7177232772810385e-05, 4.970617010258138e-05, 4.9797807150753215e-05, 4.741702650790103e-05, 4.265120151103474e-05, 3.570735134417191e-05, 2.6903333491645753e-05, 1.6653457350912504e-05, 5.449036507343408e-06, -6.165055310702883e-06, -1.7616826880839653e-05, -2.8335274691926315e-05, -3.777878373512067e-05, -4.546243144432083e-05, -5.098278052173555e-05, -5.403895920608193e-05, -5.444886483019218e-05, -5.215968849370256e-05, -4.7252135118469596e-05, -3.9937993278726935e-05, -3.0551273084711283e-05, -1.9533046724973246e-05, -7.410833404719597e-06, 5.226567736826837e-06, 1.7757613022695296e-05, 2.955851778096985e-05, 4.0034225094132125e-05, 4.864836228080094e-05, 5.49505784874782e-05, 5.859998782398179e-05, 5.9383433836046606e-05, 5.7227607612730935e-05, 5.220438106334768e-05, 4.452894791029394e-05, 3.455087426118553e-05, 2.2738311599823646e-05, 9.656127076596022e-06, -4.061001163790934e-06, -1.773930671333801e-05, -3.069896047236398e-05, -4.228778925607912e-05, -5.191401214688085e-05, -5.9076362958876416e-05, -6.339007813949138e-05, -6.460740405600518e-05, -6.2631479522679e-05, -5.7522956922184676e-05, -4.949882713845e-05, -3.892346649081446e-05, -2.629225309647154e-05, -1.220847752847476e-05, 2.6453863029018976e-06, 1.7540660337544978e-05, 3.1738138204673305e-05, 4.452470238902606e-05, 5.5249056458706036e-05, 6.33547970210202e-05, 6.840917194494978e-05, 7.012601417955011e-05, 6.838160334154963e-05, 6.322276021819562e-05, 5.4866432037670165e-05, 4.369084854261018e-05, 3.021862721652724e-05, 1.5092430658114608e-05, -9.555861879562144e-07, -1.7139131159638055e-05, -3.265621853643097e-05, -4.672884097089991e-05, -5.864188278792426e-05, -6.777937232982367e-05, -7.365621422650293e-05, -7.594375347252935e-05, -7.44878634577617e-05, -6.931859388714656e-05, -6.065074558136985e-05, -4.887529939878732e-05, -3.4541932109277695e-05, -1.833352325775195e-05, -1.033721559906553e-06, 1.6510857676621526e-05, 3.34319774992764e-05, 4.888266994385049e-05, 6.207953992998227e-05, 7.234239456010982e-05, 7.912916771601886e-05, 8.206436177715659e-05, 8.095960220089182e-05, 7.582499529235065e-05, 6.687087443424389e-05, 5.449953823699616e-05, 3.92874026147183e-05, 2.1958279830869287e-05, 3.349057124069077e-06, -1.5630626876372844e-05, -3.4042761399177834e-05, -5.096722816233523e-05, -6.554771243827417e-05, -7.703489973209798e-05, -8.482490375172347e-05, -8.849076402839273e-05, -8.780568168731406e-05, -8.275635627796873e-05, -7.354602712439373e-05, -6.058671715436503e-05, -4.448100662557408e-05, -2.599422623461578e-05, -6.018156000209274e-06, 1.4471857866737992e-05, 3.4464450436644256e-05, 5.2962059271521866e-05, 6.903062603669241e-05, 8.184662874555215e-05, 9.073920227820054e-05, 9.52250265982002e-05, 9.503438195679337e-05, 9.012679947772995e-05, 8.069552131928504e-05, 6.716039206366986e-05, 5.014944326831028e-05, 3.0469889679807238e-05, 9.069990483112633e-06, -1.3006559129280504e-05, -3.467142232693732e-05, -5.484518624143675e-05, -7.251106580952182e-05, -8.676598372403532e-05, -9.686667908681557e-05, -0.00010226826998405159, -0.00010265334276482463, -9.795014193514362e-05, -8.83386965142563e-05, -7.424454088322818e-05, -5.632012471323833e-05, -3.541481783031486e-05, -1.2534786947071552e-05, 1.1205309419892728e-05, 3.463651592028327e-05, 5.659306043526158e-05, 7.597025251016021e-05, 9.177993342746049e-05, 0.00010320076398784295, 0.00010962071246467531, 0.00011066957813454792, 0.00010623990237945691, 9.649497224017978e-05, 8.18635307950899e-05, 6.302123074419796e-05, 4.085959153599106e-05, 1.6444055290776305e-05, -9.03721411305014e-06, -3.433098390814848e-05, -5.8180507039651275e-05, -7.938786438899115e-05, -9.68740350799635e-05, -0.00010973360622301698, -0.00011728156096069142, -0.00011908944725291803, -0.0001150093085016124, -0.00010518378985580057, -9.00421291589737e-05, -7.028163236100227e-05, -4.683585211751051e-05, -2.083062645397149e-05, 6.46987246000208e-06, 3.372445280547254e-05, 5.958069232292473e-05, 8.274196443380788e-05, 0.00010203231795458123, 0.00011645606718957424, 0.00012524898920673877, 0.0001279185526072979, 0.00012427115871105343, 0.00011442462709965184, 9.880551078822464e-05, 7.813102274667472e-05, 5.337632683222182e-05, 2.572868106653914e-05, -3.4693239285843447e-06, -3.278485746704973e-05, -6.076505815144628e-05, -8.600891305832192e-05, -0.0001072373052011244, -0.00012335769133642316, -0.00013352013775147498, -0.00013716182729694992, -0.00013403799675870687, -0.000124236976262182, -0.00010817928705364466, -8.659987361170352e-05, -6.051486707292497e-05, -3.117380401818082e-05, 1.3907877743366992e-18, 3.1478415621677414e-05, 6.170327105792239e-05, 8.916335355024785e-05, 0.00011246991925872862, 0.00013042664795648307, 0.00014209102664608508, 0.0001468234258936718, 0.0001443219225620851, 0.00013464043149724603, 0.00011818948405561969, 9.571947884978727e-05, 6.828649929957464e-05, 3.7203048123046756e-05, 3.975342679041205e-06, -2.9769524189759977e-05, -6.236314948182553e-05, -9.217816841555759e-05, -0.00011770940909627825, -0.00013764969480689615, -0.00015095662092790008, -0.00015690679720137268, -0.00015513475227635354, -0.0001456545724067837, -0.00012886269541922957, -0.00010552201274549589, -7.672749052289873e-05, -4.385497959447093e-05, -8.495694601151627e-06, 2.7620719265541993e-05, 6.271061283769086e-05, 9.502435568720102e-05, 0.00012293335748836398, 0.00014501213445328176, 0.00016011072148103267, 0.0001674145896686241, 0.00016648795281071216, 0.00015729916049167514, 0.00014022596587892622, 0.00011604063183767721, 8.587543561588973e-05, 5.116981265018694e-05, 1.3601880709757097e-05, -2.499256152077578e-05, -6.270960147958249e-05, -9.767102164914832e-05, -0.00012811763735953718, -0.00015249777061399072, -0.000169546008692123, -0.00017834873870015144, -0.00017839267093222588, -0.0001695941318757832, -0.00015230700955726206, -0.00012730949674732983, -9.576932643540204e-05, -5.9189445892116055e-05, -1.9336666809977032e-05, 2.1843557988177054e-05, 6.232195300981402e-05, 0.00010008525714511052, 0.00013323627354111522, 0.00016008895181585103, 0.0001792539842426777, 0.00018971045210491866, 0.00019085983512923121, 0.0001825595390982926, 0.00016513421724084765, 0.00013936395407654345, 0.00010644969734130427, 6.795765511924401e-05, 2.5744888262124732e-05, -1.8130029275198467e-05, -6.150730769149959e-05, -0.00010223212302662432, -0.00013826142821926624, -0.00016776641132310033, -0.00018922501476481557, -0.00020150025375187397, -0.00020390011195559055, -0.00019621584215201437, -0.00017873682372737676, -0.00015224056551232934, -0.00011795876343967393, -7.752016972517595e-05, -3.28735877701547e-05, 1.3805974049319047e-05, 6.022304660291411e-05, 0.00010407443915028125, 0.00014316337183117867, 0.00017550933989696205, 0.00019944828818552196, 0.00021371796901803464, 0.0002175240806536749, 0.0002105838939314708, 0.00019314496603328735, 0.0001659773988649249, 0.00013034055882599205, 8.792493463261053e-05, 4.0772196371108294e-05, -8.822917152429e-06, -5.84240369789768e-05, -0.00010557276254985482, -0.00014791027933824807, -0.00018329524027649313, -0.00020991185738239437, -0.00022636281209997833, -0.00023174224770627916, -0.0002256850857520476, -0.00020838987256865948, -0.0001806140353437513, -0.0001436411839677021, -9.922225581249222e-05, -4.9492737161926925e-05, 3.129695414827438e-06, 5.6062581279547885e-05, 0.00010668523464119062, 0.00015246830298565328, 0.0001911000144900754, 0.00022060262563172728, 0.00023943348787724972, 0.0002465652651153505, 0.0002415414637653157, 0.00022450413962360471, 0.00019619199156295508, 0.00015790907491464168, 0.00011146506585646421, 5.9090085414936766e-05, 3.3277508464379935e-06, -5.308812978910282e-05, -0.00010736739204730839, -0.00015680136857554317, -0.00019889780378434807, -0.0002315063466085121, -0.00025292811915278435, -0.00026200388674624264, -0.0002581760345492512, -0.00024152187688741833, -0.00021275489416439086, -0.00017319517792202532, -0.00012470927322283387, -6.962225597817451e-05, -1.0606659998302348e-05, 4.944709871779196e-05, 0.0001075720283552073, 0.00016087102994788438, 0.00020666095952037722, 0.00024260768259409815, 0.00026684461045078933, 0.000278069288469851, 0.00027561295428313315, 0.00025947901303879917, 0.00023034874175209552, 0.00018955348059535027, 0.0001390140241710469, 8.115073433145881e-05, 1.8767763322102837e-05, -4.5082571887178347e-05, -0.00010724895400926471, -0.00016463641077280045, -0.00021436008682940155, -0.0002538902626838535, -0.00028118042973801494, -0.0002947732573375106, -0.0002938776451628655, -0.0002784135867841542, -0.00024902247241698205, -0.00020704120106529444, -0.00015444221207872033, -9.37408913159743e-05, -2.7875661544385366e-05, 3.993399877799675e-05, 0.00010634473437676206, 0.00016805394261609763, 0.00022196379723027349, 0.0002653365081641823, 0.0002959330449812114, 0.0003121283953078091, 0.0003129973483737558, 0.00029836632893420756, 0.0002688281238079071, 0.00022571953013539314, 0.00017106100858654827, 0.00010746251791715622, 3.7999285268597305e-05, -3.3936783438548446e-05, -0.00010480242053745314, -0.00017107732128351927, -0.00022943876683712006, -0.0002769279817584902, -0.0003110998368356377, -0.00033014826476573944, -0.00033300142968073487, -0.00031938086613081396, -0.000289821793558076, -0.00024565402418375015, -0.00018894228560384363, -0.00012239035277161747, -4.921241998090409e-05, 2.7021838832297362e-05, 0.00010256116365781054, 0.0001736570557113737, 0.00023674954718444496, 0.00028864521300420165, 0.0003266784187871963, 0.00034884794149547815, 0.0003539217577781528, 0.0003415044629946351, 0.000312063901219517, 0.00026691542007029057, 0.00020816356118302792, 0.00013860478065907955, 6.159433542052284e-05, -1.9115021132165566e-05, -9.955577115761116e-05, -0.00017574032244738191, -0.00024385850701946765, -0.000300467771012336, -0.00034266692819073796, -0.00036824436392635107, -0.00037579337367787957, -0.0003647887788247317, -0.0003356201050337404, -0.0002895802608691156, -0.000228808683459647, -0.0001561926765134558, -7.523057865910232e-05, 1.0136512173630763e-05, 9.571624104864895e-05, 0.0001772706164047122, 0.0002507256285753101, 0.00031237443909049034, 0.0003590641135815531, 0.0003883564786519855, 0.00039865486905910075, 0.0003892902168445289, 0.00036056223325431347, 0.0003137321618851274, 0.0002509687910787761, 0.00017524836584925652, 9.021380537888035e-05, -4.6256804257705425e-18, -9.096709982259199e-05, -0.00017818727064877748, -0.00025730833294801414, -0.00032434306922368705, -0.0003758697130251676, -0.0004092062881682068, -0.00042254949221387506, -0.00041507158312015235, -0.00038696930278092623, -0.0003394628583919257, -0.0002747438265942037, -0.0001958748180186376, -0.00010664497676771134, -1.1388235179765616e-05, 8.522671123500913e-05, 0.00017842501983977854, 0.0002635612909216434, 0.00033635087311267853, 0.0003930848906747997, 0.00043081905459985137, 0.0004475258756428957, 0.00044220240670256317, 0.00041492885793559253, 0.00036687339888885617, 0.0003002434968948364, 0.00021818502864334732, 0.00012463452003430575, 2.413046058791224e-05, -7.840633043088019e-05, -0.00017791337450034916, -0.00026943610282614827, -0.00034837418934330344, -0.0004107124113943428, -0.00045322440564632416, -0.00047363905468955636, -0.00047076091868802905, -0.0004445384838618338, -0.00039607621147297323, -0.00032758936868049204, -0.00024230372218880802, -0.00014430400915443897, -3.8338843296514824e-05, 7.040903437882662e-05, 0.00017657583521213382, 0.00027488087653182447, 0.0003603889199439436, 0.0004287575138732791, 0.0004764569166582078, 0.0005009517772123218, 0.000500835245475173, 0.0004759076691698283, 0.0004271967045497149, 0.00035691686207428575, 0.0002683693601284176, 0.00016578803479205817, 5.4137108236318454e-05, -6.112844857852906e-05, -0.00017432906315661967, -0.00027983999461866915, -0.00037237038486637175, -0.00044722817256115377, -0.0005005573621019721, -0.0005295362789183855, -0.0005325256497599185, -0.0005091600469313562, -0.00046037608990445733, -0.00038837763713672757, -0.00029653668752871454, -0.00018923645257018507, -7.166252180468291e-05, 5.0447124522179365e-05, 0.00017108177416957915, 0.00028425335767678916, 0.00038429329288192093, 0.0004661358252633363, 0.0005255740834400058, 0.000559475680347532, 0.0005659466842189431, 0.0005444360431283712, 0.0004957740311510861, 0.00042214285349473357, 0.00032697964343242347, 0.00021481722069438547, 9.106837387662381e-05, -3.8234553358051926e-05, -0.00016673329810146242, -0.0002880559186451137, -0.0003961321199312806, -0.0004854965372942388, -0.0005515645607374609, -0.0005908666644245386, -0.0006012299563735723, -0.000581896398216486, -0.0005335725145414472, -0.00045840672100894153, -0.0003598951443564147, -0.0002427198487566784, -0.00011252694093855098, 2.434480302326847e-05, 0.0001611720654182136, 0.0002911766932811588, 0.0004078609053976834, 0.0005053316126577556, 0.0005785970133729279, 0.0006238220958039165, 0.0006385278538800776, 0.0006217259215191007, 0.0005739799235016108, 0.0004973913310095668, 0.0003955075517296791, 0.0002731596177909523, 0.00013623324048239738, -8.613516911282204e-06, -0.00015427335165441036, -0.00029353785794228315, -0.00041945368866436183, -0.0005256690201349556, -0.0006067533977329731, -0.0006584744551219046, -0.000678017851896584, -0.000664138759020716, -0.0006172371795400977, -0.0005393519531935453, -0.00043407423072494566, -0.0003063828335143626, -0.0001624096039449796, -9.14580868993653e-06, 0.0001458967599319294, 0.0002950532943941653, 0.00043088404345326126, 0.0005465449648909271, 0.0006361316773109138, 0.0006949800299480557, 0.0007199075189419091, 0.0007093846215866506, 0.0006636236794292927, 0.0005845847190357745, 0.0004758928553201258, 0.00034267344744876027, 0.0001913115120260045, 2.9146469387342222e-05, -0.00013588306319434196, -0.0002956270473077893, -0.0004421257763169706, -0.000568005780223757, -0.0006668499554507434, -0.0007335240952670574, -0.0007644417928531766, -0.0007577562355436385, -0.000713466783054173, -0.0006334351492114365, -0.000521309906616807, -0.00038236123509705067, -0.00022323481971397996, -5.163443347555585e-05, 0.00012404986773617566, 0.00029515125788748264, 0.0004531526647042483, 0.0005901101394556463, 0.0006990510155446827, 0.0007743280148133636, 0.0008119108970277011, 0.0008095999946817756, 0.0007671521161682904, 0.0006863095331937075, 0.0005707319942303002, 0.000425832491600886, 0.00025852504768408835, 7.689587073400617e-05, -0.00011018651275662705, -0.0002935032534878701, -0.0004639385442715138, -0.0006129320245236158, -0.0007329074433073401, -0.0008176571573130786, -0.0008626613416709006, -0.0008653277764096856, -0.0008251374820247293, -0.0007436894229613245, -0.000624640379101038, -0.0004735433612950146, -0.0002975893148686737, -0.00010526673577260226, 9.404715819982812e-05, 0.0002905423170886934, 0.0004744576581288129, 0.0006365649751387537, 0.0007686304743401706, 0.0008638321305625141, 0.0009171100682578981, 0.0009254338219761848, 0.0008879714296199381, 0.0008061505504883826, 0.0006836095126345754, 0.0005260373582132161, 0.00034091173438355327, 0.00013714533997699618, -7.53419881220907e-05, -0.0002861048560589552, -0.0004846844240091741, -0.0006611263961531222, -0.000806478492449969, -0.0009132429258897901, -0.0009757621446624398, -0.0009905158076435328, -0.0009563157800585032, -0.0008743872167542577, -0.0007483310182578862, -0.0005839684163220227, -0.0003890737716574222, -0.00017300885519944131, 5.3725547331850976e-05, 0.0002799984940793365, 0.0004945938126184046, 0.0006867647171020508, 0.0008467703592032194, 0.0009663678938522935, 0.0010392351541668177, 0.0010613027261570096, 0.001030977233313024, 0.0009492445969954133, 0.0008196467533707619, 0.0006481313030235469, 0.0004427810781635344, 0.0002134351379936561, -2.8781170840375125e-05, -0.0002719939511734992, -0.0005041611730121076, -0.0007136673084460199, -0.0008899026433937252, -0.0010237981332466006, -0.001108290976844728, -0.0011386933038011193, -0.001112949219532311, -0.0010317628039047122, -0.0008985913009382784, -0.0007195024518296123, -0.0005028999876230955, -0.00025913238641805947, 6.649994457528183e-18, 0.00026181404246017337, 0.0005133626400493085, 0.0007420728215947747, 0.0009363722638227046, 0.0010862721828743815, 0.0011838792124763131, 0.0012238062918186188, 0.0012034679530188441, 0.0011232357937842607, 0.0009864522144198418, 0.0007992960745468736, 0.0005705069634132087, 0.0003109796380158514, 3.3247888495679945e-05, -0.0002491186314728111, -0.0005221748142503202, -0.0007722866139374673, -0.0009868089109659195, -0.00115472252946347, -0.001267197192646563, -0.001318052178248763, -0.0013040914200246334, -0.0012252941960468888, -0.0010848513338714838, -0.000889042392373085, -0.0006469582440331578, -0.000370083493180573, -7.175379141699523e-05, 0.0002334834134671837, 0.0005305754020810127, 0.0008047035080380738, 0.0010420193430036306, 0.00123034103307873, 0.001359775080345571, 0.0014232321409508586, 0.0014168096240609884, 0.0013400219613686204, 0.0011958626564592123, 0.0009906975319609046, 0.0007339878939092159, 0.0004378583689685911, 0.00011652784451143816, -0.00021436979295685887, -0.0005385427502915263, -0.0008398398058488965, -0.001103051588870585, -0.0013146739220246673, -0.0014635968254879117, -0.0015416829846799374, -0.001544205704703927, -0.001470124232582748, -0.0013221793342381716, -0.0011068042367696762, -0.0008338508778251708, -0.000516143802087754, -0.00016888270329218358, 0.00019108070409856737, 0.0005460561951622367, 0.0008783797966316342, 0.001171288313344121, 0.001409759745001793, 0.0015812789788469672, 0.0016764882020652294, 0.001689690281637013, 0.0016191770555451512, 0.0014673653058707714, 0.0012407297035679221, 0.000949535402469337, 0.0006073787808418274, 0.00023055872588884085, -0.00016269460320472717, -0.0005530961789190769, -0.00092124636285007, -0.001248588552698493, -0.0015183392679318786, -0.0017163412412628531, -0.0018317995127290487, -0.0018578609451651573, -0.0017920067766681314, -0.0016362359747290611, -0.0013970290310680866, -0.001085088704712689, -0.000714869995135814, -0.00030391637119464576, 0.00012796357623301446, 0.0005596443661488593, 0.0009697095374576747, 0.0013375068083405495, 0.0016441801562905312, 0.00187362777069211, 0.002013338962569833, 0.0020550640765577555, 0.0019952848087996244, 0.001835458679124713, 0.0015820191474631429, 0.0012461327714845538, 0.0008432171307504177, 0.00039224274223670363, -8.515059744240716e-05, -0.0005656833527609706, -0.001025561592541635, -0.0014416450867429376, -0.0017926020082086325, -0.0020599898416548967, -0.0022292137145996094, -0.002290307777002454, -0.0022385010961443186, -0.0020745364017784595, -0.001804722473025322, -0.0014407126000151038, -0.0009990152902901173, -0.0005002589896321297, 3.175938400090672e-05, 0.0005711971316486597, 0.0010914079612120986, 0.0015662448713555932, 0.0019713598303496838, 0.0022854364942759275, 0.0024912962689995766, 0.0025768170598894358, 0.0025356209371238947, 0.0023674897383898497, 0.002078484743833542, 0.0016807597130537033, 0.0011920711258426309, 0.0006350020412355661, 3.59369587386027e-05, -0.0005761710926890373, -0.0011711812112480402, -0.0017192293889820576, -0.002192207146435976, -0.0025651820469647646, -0.0028176873456686735, -0.0029348169919103384, -0.0029080715030431747, -0.0027359002269804478, -0.002423915546387434, -0.0019847608637064695, -0.0014376287581399083, -0.00080744648585096, -0.00012376694940030575, 0.0005805919063277543, 0.0012710957089439034, 0.001913158455863595, 0.00247384374961257, 0.00292352307587862, 0.0032374050933867693, 0.003396861720830202, 0.0033904805313795805, 0.0032147890888154507, 0.0028746011666953564, 0.0023829734418541193, 0.0017607474001124501, 0.0010357110295444727, 0.00024139281595125794, -0.0005844476982019842, -0.0014015737688168883, -0.0021691867150366306, -0.002847915282472968, -0.003401783062145114, -0.003800058737397194, -0.004018895328044891, -0.004042678512632847, -0.0038650003261864185, -0.003489220980554819, -0.002928559435531497, -0.0022057134192436934, -0.001352005871012807, -0.000406091712648049, 0.0005877281655557454, 0.0015815109945833683, 0.002525910036638379, 0.003372541395947337, 0.004076373763382435, 0.004598023369908333, 0.004905842710286379, 0.004977701231837273, 0.004802354611456394, 0.004380337428301573, 0.0037243138067424297, 0.0028588545974344015, 0.0018196417950093746, 0.0006521090981550515, -0.0005904243444092572, -0.001849060645326972, -0.0030619718600064516, -0.004167277365922928, -0.005106025841087103, -0.005825136788189411, -0.00628017308190465, -0.006437803152948618, -0.006277826149016619, -0.005794658791273832, -0.004998188931494951, -0.003913940396159887, -0.0025825095362961292, -0.0010582847753539681, 0.0005925290170125663, 0.0022945089731365442, 0.003966146614402533, 0.005523386411368847, 0.0068834321573376656, 0.0079686613753438, 0.008710469119250774, 0.009052888490259647, 0.008955799974501133, 0.008397581987082958, 0.0073770880699157715, 0.0059147970750927925, 0.004053107462823391, 0.001855697249993682, -0.0005940364208072424, -0.0031954331789165735, -0.005833843257278204, -0.008384611457586288, -0.010717632248997688, -0.012702303007245064, -0.014212685637176037, -0.015132686123251915, -0.015361011028289795, -0.01481575146317482, -0.01343833189457655, -0.011196720413863659, -0.008087699301540852, -0.004138120915740728, 0.0005949424812570214, 0.006025177892297506, 0.012039124965667725, 0.018499325960874557, 0.025248434394598007, 0.03211412951350212, 0.03891469165682793, 0.04546498507261276, 0.05158267915248871, 0.05709446594119072, 0.06184202432632446, 0.06568747013807297, 0.06851819157600403, 0.07025083154439926, 0.07083413004875183, 0.07025083154439926, 0.06851819157600403, 0.06568747013807297, 0.06184202432632446, 0.05709446594119072, 0.05158267915248871, 0.04546498507261276, 0.03891469165682793, 0.03211412951350212, 0.025248434394598007, 0.018499325960874557, 0.012039124965667725, 0.006025177892297506, 0.0005949424812570214, -0.004138120915740728, -0.008087699301540852, -0.011196720413863659, -0.01343833189457655, -0.01481575146317482, -0.015361011028289795, -0.015132686123251915, -0.014212685637176037, -0.012702303007245064, -0.010717632248997688, -0.008384611457586288, -0.005833843257278204, -0.0031954331789165735, -0.0005940364208072424, 0.001855697249993682, 0.004053107462823391, 0.0059147970750927925, 0.0073770880699157715, 0.008397581987082958, 0.008955799974501133, 0.009052888490259647, 0.008710469119250774, 0.0079686613753438, 0.0068834321573376656, 0.005523386411368847, 0.003966146614402533, 0.0022945089731365442, 0.0005925290170125663, -0.0010582847753539681, -0.0025825095362961292, -0.003913940396159887, -0.004998188931494951, -0.005794658791273832, -0.006277826149016619, -0.006437803152948618, -0.00628017308190465, -0.005825136788189411, -0.005106025841087103, -0.004167277365922928, -0.0030619718600064516, -0.001849060645326972, -0.0005904243444092572, 0.0006521090981550515, 0.0018196417950093746, 0.0028588545974344015, 0.0037243138067424297, 0.004380337428301573, 0.004802354611456394, 0.004977701231837273, 0.004905842710286379, 0.004598023369908333, 0.004076373763382435, 0.003372541395947337, 0.002525910036638379, 0.0015815109945833683, 0.0005877281655557454, -0.000406091712648049, -0.001352005871012807, -0.0022057134192436934, -0.002928559435531497, -0.003489220980554819, -0.0038650003261864185, -0.004042678512632847, -0.004018895328044891, -0.003800058737397194, -0.003401783062145114, -0.002847915282472968, -0.0021691867150366306, -0.0014015737688168883, -0.0005844476982019842, 0.00024139281595125794, 0.0010357110295444727, 0.0017607474001124501, 0.0023829734418541193, 0.0028746011666953564, 0.0032147890888154507, 0.0033904805313795805, 0.003396861720830202, 0.0032374050933867693, 0.00292352307587862, 0.00247384374961257, 0.001913158455863595, 0.0012710957089439034, 0.0005805919063277543, -0.00012376694940030575, -0.00080744648585096, -0.0014376287581399083, -0.0019847608637064695, -0.002423915546387434, -0.0027359002269804478, -0.0029080715030431747, -0.0029348169919103384, -0.0028176873456686735, -0.0025651820469647646, -0.002192207146435976, -0.0017192293889820576, -0.0011711812112480402, -0.0005761710926890373, 3.59369587386027e-05, 0.0006350020412355661, 0.0011920711258426309, 0.0016807597130537033, 0.002078484743833542, 0.0023674897383898497, 0.0025356209371238947, 0.0025768170598894358, 0.0024912962689995766, 0.0022854364942759275, 0.0019713598303496838, 0.0015662448713555932, 0.0010914079612120986, 0.0005711971316486597, 3.175938400090672e-05, -0.0005002589896321297, -0.0009990152902901173, -0.0014407126000151038, -0.001804722473025322, -0.0020745364017784595, -0.0022385010961443186, -0.002290307777002454, -0.0022292137145996094, -0.0020599898416548967, -0.0017926020082086325, -0.0014416450867429376, -0.001025561592541635, -0.0005656833527609706, -8.515059744240716e-05, 0.00039224274223670363, 0.0008432171307504177, 0.0012461327714845538, 0.0015820191474631429, 0.001835458679124713, 0.0019952848087996244, 0.0020550640765577555, 0.002013338962569833, 0.00187362777069211, 0.0016441801562905312, 0.0013375068083405495, 0.0009697095374576747, 0.0005596443661488593, 0.00012796357623301446, -0.00030391637119464576, -0.000714869995135814, -0.001085088704712689, -0.0013970290310680866, -0.0016362359747290611, -0.0017920067766681314, -0.0018578609451651573, -0.0018317995127290487, -0.0017163412412628531, -0.0015183392679318786, -0.001248588552698493, -0.00092124636285007, -0.0005530961789190769, -0.00016269460320472717, 0.00023055872588884085, 0.0006073787808418274, 0.000949535402469337, 0.0012407297035679221, 0.0014673653058707714, 0.0016191770555451512, 0.001689690281637013, 0.0016764882020652294, 0.0015812789788469672, 0.001409759745001793, 0.001171288313344121, 0.0008783797966316342, 0.0005460561951622367, 0.00019108070409856737, -0.00016888270329218358, -0.000516143802087754, -0.0008338508778251708, -0.0011068042367696762, -0.0013221793342381716, -0.001470124232582748, -0.001544205704703927, -0.0015416829846799374, -0.0014635968254879117, -0.0013146739220246673, -0.001103051588870585, -0.0008398398058488965, -0.0005385427502915263, -0.00021436979295685887, 0.00011652784451143816, 0.0004378583689685911, 0.0007339878939092159, 0.0009906975319609046, 0.0011958626564592123, 0.0013400219613686204, 0.0014168096240609884, 0.0014232321409508586, 0.001359775080345571, 0.00123034103307873, 0.0010420193430036306, 0.0008047035080380738, 0.0005305754020810127, 0.0002334834134671837, -7.175379141699523e-05, -0.000370083493180573, -0.0006469582440331578, -0.000889042392373085, -0.0010848513338714838, -0.0012252941960468888, -0.0013040914200246334, -0.001318052178248763, -0.001267197192646563, -0.00115472252946347, -0.0009868089109659195, -0.0007722866139374673, -0.0005221748142503202, -0.0002491186314728111, 3.3247888495679945e-05, 0.0003109796380158514, 0.0005705069634132087, 0.0007992960745468736, 0.0009864522144198418, 0.0011232357937842607, 0.0012034679530188441, 0.0012238062918186188, 0.0011838792124763131, 0.0010862721828743815, 0.0009363722638227046, 0.0007420728215947747, 0.0005133626400493085, 0.00026181404246017337, 6.649994457528183e-18, -0.00025913238641805947, -0.0005028999876230955, -0.0007195024518296123, -0.0008985913009382784, -0.0010317628039047122, -0.001112949219532311, -0.0011386933038011193, -0.001108290976844728, -0.0010237981332466006, -0.0008899026433937252, -0.0007136673084460199, -0.0005041611730121076, -0.0002719939511734992, -2.8781170840375125e-05, 0.0002134351379936561, 0.0004427810781635344, 0.0006481313030235469, 0.0008196467533707619, 0.0009492445969954133, 0.001030977233313024, 0.0010613027261570096, 0.0010392351541668177, 0.0009663678938522935, 0.0008467703592032194, 0.0006867647171020508, 0.0004945938126184046, 0.0002799984940793365, 5.3725547331850976e-05, -0.00017300885519944131, -0.0003890737716574222, -0.0005839684163220227, -0.0007483310182578862, -0.0008743872167542577, -0.0009563157800585032, -0.0009905158076435328, -0.0009757621446624398, -0.0009132429258897901, -0.000806478492449969, -0.0006611263961531222, -0.0004846844240091741, -0.0002861048560589552, -7.53419881220907e-05, 0.00013714533997699618, 0.00034091173438355327, 0.0005260373582132161, 0.0006836095126345754, 0.0008061505504883826, 0.0008879714296199381, 0.0009254338219761848, 0.0009171100682578981, 0.0008638321305625141, 0.0007686304743401706, 0.0006365649751387537, 0.0004744576581288129, 0.0002905423170886934, 9.404715819982812e-05, -0.00010526673577260226, -0.0002975893148686737, -0.0004735433612950146, -0.000624640379101038, -0.0007436894229613245, -0.0008251374820247293, -0.0008653277764096856, -0.0008626613416709006, -0.0008176571573130786, -0.0007329074433073401, -0.0006129320245236158, -0.0004639385442715138, -0.0002935032534878701, -0.00011018651275662705, 7.689587073400617e-05, 0.00025852504768408835, 0.000425832491600886, 0.0005707319942303002, 0.0006863095331937075, 0.0007671521161682904, 0.0008095999946817756, 0.0008119108970277011, 0.0007743280148133636, 0.0006990510155446827, 0.0005901101394556463, 0.0004531526647042483, 0.00029515125788748264, 0.00012404986773617566, -5.163443347555585e-05, -0.00022323481971397996, -0.00038236123509705067, -0.000521309906616807, -0.0006334351492114365, -0.000713466783054173, -0.0007577562355436385, -0.0007644417928531766, -0.0007335240952670574, -0.0006668499554507434, -0.000568005780223757, -0.0004421257763169706, -0.0002956270473077893, -0.00013588306319434196, 2.9146469387342222e-05, 0.0001913115120260045, 0.00034267344744876027, 0.0004758928553201258, 0.0005845847190357745, 0.0006636236794292927, 0.0007093846215866506, 0.0007199075189419091, 0.0006949800299480557, 0.0006361316773109138, 0.0005465449648909271, 0.00043088404345326126, 0.0002950532943941653, 0.0001458967599319294, -9.14580868993653e-06, -0.0001624096039449796, -0.0003063828335143626, -0.00043407423072494566, -0.0005393519531935453, -0.0006172371795400977, -0.000664138759020716, -0.000678017851896584, -0.0006584744551219046, -0.0006067533977329731, -0.0005256690201349556, -0.00041945368866436183, -0.00029353785794228315, -0.00015427335165441036, -8.613516911282204e-06, 0.00013623324048239738, 0.0002731596177909523, 0.0003955075517296791, 0.0004973913310095668, 0.0005739799235016108, 0.0006217259215191007, 0.0006385278538800776, 0.0006238220958039165, 0.0005785970133729279, 0.0005053316126577556, 0.0004078609053976834, 0.0002911766932811588, 0.0001611720654182136, 2.434480302326847e-05, -0.00011252694093855098, -0.0002427198487566784, -0.0003598951443564147, -0.00045840672100894153, -0.0005335725145414472, -0.000581896398216486, -0.0006012299563735723, -0.0005908666644245386, -0.0005515645607374609, -0.0004854965372942388, -0.0003961321199312806, -0.0002880559186451137, -0.00016673329810146242, -3.8234553358051926e-05, 9.106837387662381e-05, 0.00021481722069438547, 0.00032697964343242347, 0.00042214285349473357, 0.0004957740311510861, 0.0005444360431283712, 0.0005659466842189431, 0.000559475680347532, 0.0005255740834400058, 0.0004661358252633363, 0.00038429329288192093, 0.00028425335767678916, 0.00017108177416957915, 5.0447124522179365e-05, -7.166252180468291e-05, -0.00018923645257018507, -0.00029653668752871454, -0.00038837763713672757, -0.00046037608990445733, -0.0005091600469313562, -0.0005325256497599185, -0.0005295362789183855, -0.0005005573621019721, -0.00044722817256115377, -0.00037237038486637175, -0.00027983999461866915, -0.00017432906315661967, -6.112844857852906e-05, 5.4137108236318454e-05, 0.00016578803479205817, 0.0002683693601284176, 0.00035691686207428575, 0.0004271967045497149, 0.0004759076691698283, 0.000500835245475173, 0.0005009517772123218, 0.0004764569166582078, 0.0004287575138732791, 0.0003603889199439436, 0.00027488087653182447, 0.00017657583521213382, 7.040903437882662e-05, -3.8338843296514824e-05, -0.00014430400915443897, -0.00024230372218880802, -0.00032758936868049204, -0.00039607621147297323, -0.0004445384838618338, -0.00047076091868802905, -0.00047363905468955636, -0.00045322440564632416, -0.0004107124113943428, -0.00034837418934330344, -0.00026943610282614827, -0.00017791337450034916, -7.840633043088019e-05, 2.413046058791224e-05, 0.00012463452003430575, 0.00021818502864334732, 0.0003002434968948364, 0.00036687339888885617, 0.00041492885793559253, 0.00044220240670256317, 0.0004475258756428957, 0.00043081905459985137, 0.0003930848906747997, 0.00033635087311267853, 0.0002635612909216434, 0.00017842501983977854, 8.522671123500913e-05, -1.1388235179765616e-05, -0.00010664497676771134, -0.0001958748180186376, -0.0002747438265942037, -0.0003394628583919257, -0.00038696930278092623, -0.00041507158312015235, -0.00042254949221387506, -0.0004092062881682068, -0.0003758697130251676, -0.00032434306922368705, -0.00025730833294801414, -0.00017818727064877748, -9.096709982259199e-05, -4.6256804257705425e-18, 9.021380537888035e-05, 0.00017524836584925652, 0.0002509687910787761, 0.0003137321618851274, 0.00036056223325431347, 0.0003892902168445289, 0.00039865486905910075, 0.0003883564786519855, 0.0003590641135815531, 0.00031237443909049034, 0.0002507256285753101, 0.0001772706164047122, 9.571624104864895e-05, 1.0136512173630763e-05, -7.523057865910232e-05, -0.0001561926765134558, -0.000228808683459647, -0.0002895802608691156, -0.0003356201050337404, -0.0003647887788247317, -0.00037579337367787957, -0.00036824436392635107, -0.00034266692819073796, -0.000300467771012336, -0.00024385850701946765, -0.00017574032244738191, -9.955577115761116e-05, -1.9115021132165566e-05, 6.159433542052284e-05, 0.00013860478065907955, 0.00020816356118302792, 0.00026691542007029057, 0.000312063901219517, 0.0003415044629946351, 0.0003539217577781528, 0.00034884794149547815, 0.0003266784187871963, 0.00028864521300420165, 0.00023674954718444496, 0.0001736570557113737, 0.00010256116365781054, 2.7021838832297362e-05, -4.921241998090409e-05, -0.00012239035277161747, -0.00018894228560384363, -0.00024565402418375015, -0.000289821793558076, -0.00031938086613081396, -0.00033300142968073487, -0.00033014826476573944, -0.0003110998368356377, -0.0002769279817584902, -0.00022943876683712006, -0.00017107732128351927, -0.00010480242053745314, -3.3936783438548446e-05, 3.7999285268597305e-05, 0.00010746251791715622, 0.00017106100858654827, 0.00022571953013539314, 0.0002688281238079071, 0.00029836632893420756, 0.0003129973483737558, 0.0003121283953078091, 0.0002959330449812114, 0.0002653365081641823, 0.00022196379723027349, 0.00016805394261609763, 0.00010634473437676206, 3.993399877799675e-05, -2.7875661544385366e-05, -9.37408913159743e-05, -0.00015444221207872033, -0.00020704120106529444, -0.00024902247241698205, -0.0002784135867841542, -0.0002938776451628655, -0.0002947732573375106, -0.00028118042973801494, -0.0002538902626838535, -0.00021436008682940155, -0.00016463641077280045, -0.00010724895400926471, -4.5082571887178347e-05, 1.8767763322102837e-05, 8.115073433145881e-05, 0.0001390140241710469, 0.00018955348059535027, 0.00023034874175209552, 0.00025947901303879917, 0.00027561295428313315, 0.000278069288469851, 0.00026684461045078933, 0.00024260768259409815, 0.00020666095952037722, 0.00016087102994788438, 0.0001075720283552073, 4.944709871779196e-05, -1.0606659998302348e-05, -6.962225597817451e-05, -0.00012470927322283387, -0.00017319517792202532, -0.00021275489416439086, -0.00024152187688741833, -0.0002581760345492512, -0.00026200388674624264, -0.00025292811915278435, -0.0002315063466085121, -0.00019889780378434807, -0.00015680136857554317, -0.00010736739204730839, -5.308812978910282e-05, 3.3277508464379935e-06, 5.9090085414936766e-05, 0.00011146506585646421, 0.00015790907491464168, 0.00019619199156295508, 0.00022450413962360471, 0.0002415414637653157, 0.0002465652651153505, 0.00023943348787724972, 0.00022060262563172728, 0.0001911000144900754, 0.00015246830298565328, 0.00010668523464119062, 5.6062581279547885e-05, 3.129695414827438e-06, -4.9492737161926925e-05, -9.922225581249222e-05, -0.0001436411839677021, -0.0001806140353437513, -0.00020838987256865948, -0.0002256850857520476, -0.00023174224770627916, -0.00022636281209997833, -0.00020991185738239437, -0.00018329524027649313, -0.00014791027933824807, -0.00010557276254985482, -5.84240369789768e-05, -8.822917152429e-06, 4.0772196371108294e-05, 8.792493463261053e-05, 0.00013034055882599205, 0.0001659773988649249, 0.00019314496603328735, 0.0002105838939314708, 0.0002175240806536749, 0.00021371796901803464, 0.00019944828818552196, 0.00017550933989696205, 0.00014316337183117867, 0.00010407443915028125, 6.022304660291411e-05, 1.3805974049319047e-05, -3.28735877701547e-05, -7.752016972517595e-05, -0.00011795876343967393, -0.00015224056551232934, -0.00017873682372737676, -0.00019621584215201437, -0.00020390011195559055, -0.00020150025375187397, -0.00018922501476481557, -0.00016776641132310033, -0.00013826142821926624, -0.00010223212302662432, -6.150730769149959e-05, -1.8130029275198467e-05, 2.5744888262124732e-05, 6.795765511924401e-05, 0.00010644969734130427, 0.00013936395407654345, 0.00016513421724084765, 0.0001825595390982926, 0.00019085983512923121, 0.00018971045210491866, 0.0001792539842426777, 0.00016008895181585103, 0.00013323627354111522, 0.00010008525714511052, 6.232195300981402e-05, 2.1843557988177054e-05, -1.9336666809977032e-05, -5.9189445892116055e-05, -9.576932643540204e-05, -0.00012730949674732983, -0.00015230700955726206, -0.0001695941318757832, -0.00017839267093222588, -0.00017834873870015144, -0.000169546008692123, -0.00015249777061399072, -0.00012811763735953718, -9.767102164914832e-05, -6.270960147958249e-05, -2.499256152077578e-05, 1.3601880709757097e-05, 5.116981265018694e-05, 8.587543561588973e-05, 0.00011604063183767721, 0.00014022596587892622, 0.00015729916049167514, 0.00016648795281071216, 0.0001674145896686241, 0.00016011072148103267, 0.00014501213445328176, 0.00012293335748836398, 9.502435568720102e-05, 6.271061283769086e-05, 2.7620719265541993e-05, -8.495694601151627e-06, -4.385497959447093e-05, -7.672749052289873e-05, -0.00010552201274549589, -0.00012886269541922957, -0.0001456545724067837, -0.00015513475227635354, -0.00015690679720137268, -0.00015095662092790008, -0.00013764969480689615, -0.00011770940909627825, -9.217816841555759e-05, -6.236314948182553e-05, -2.9769524189759977e-05, 3.975342679041205e-06, 3.7203048123046756e-05, 6.828649929957464e-05, 9.571947884978727e-05, 0.00011818948405561969, 0.00013464043149724603, 0.0001443219225620851, 0.0001468234258936718, 0.00014209102664608508, 0.00013042664795648307, 0.00011246991925872862, 8.916335355024785e-05, 6.170327105792239e-05, 3.1478415621677414e-05, 1.3907877743366992e-18, -3.117380401818082e-05, -6.051486707292497e-05, -8.659987361170352e-05, -0.00010817928705364466, -0.000124236976262182, -0.00013403799675870687, -0.00013716182729694992, -0.00013352013775147498, -0.00012335769133642316, -0.0001072373052011244, -8.600891305832192e-05, -6.076505815144628e-05, -3.278485746704973e-05, -3.4693239285843447e-06, 2.572868106653914e-05, 5.337632683222182e-05, 7.813102274667472e-05, 9.880551078822464e-05, 0.00011442462709965184, 0.00012427115871105343, 0.0001279185526072979, 0.00012524898920673877, 0.00011645606718957424, 0.00010203231795458123, 8.274196443380788e-05, 5.958069232292473e-05, 3.372445280547254e-05, 6.46987246000208e-06, -2.083062645397149e-05, -4.683585211751051e-05, -7.028163236100227e-05, -9.00421291589737e-05, -0.00010518378985580057, -0.0001150093085016124, -0.00011908944725291803, -0.00011728156096069142, -0.00010973360622301698, -9.68740350799635e-05, -7.938786438899115e-05, -5.8180507039651275e-05, -3.433098390814848e-05, -9.03721411305014e-06, 1.6444055290776305e-05, 4.085959153599106e-05, 6.302123074419796e-05, 8.18635307950899e-05, 9.649497224017978e-05, 0.00010623990237945691, 0.00011066957813454792, 0.00010962071246467531, 0.00010320076398784295, 9.177993342746049e-05, 7.597025251016021e-05, 5.659306043526158e-05, 3.463651592028327e-05, 1.1205309419892728e-05, -1.2534786947071552e-05, -3.541481783031486e-05, -5.632012471323833e-05, -7.424454088322818e-05, -8.83386965142563e-05, -9.795014193514362e-05, -0.00010265334276482463, -0.00010226826998405159, -9.686667908681557e-05, -8.676598372403532e-05, -7.251106580952182e-05, -5.484518624143675e-05, -3.467142232693732e-05, -1.3006559129280504e-05, 9.069990483112633e-06, 3.0469889679807238e-05, 5.014944326831028e-05, 6.716039206366986e-05, 8.069552131928504e-05, 9.012679947772995e-05, 9.503438195679337e-05, 9.52250265982002e-05, 9.073920227820054e-05, 8.184662874555215e-05, 6.903062603669241e-05, 5.2962059271521866e-05, 3.4464450436644256e-05, 1.4471857866737992e-05, -6.018156000209274e-06, -2.599422623461578e-05, -4.448100662557408e-05, -6.058671715436503e-05, -7.354602712439373e-05, -8.275635627796873e-05, -8.780568168731406e-05, -8.849076402839273e-05, -8.482490375172347e-05, -7.703489973209798e-05, -6.554771243827417e-05, -5.096722816233523e-05, -3.4042761399177834e-05, -1.5630626876372844e-05, 3.349057124069077e-06, 2.1958279830869287e-05, 3.92874026147183e-05, 5.449953823699616e-05, 6.687087443424389e-05, 7.582499529235065e-05, 8.095960220089182e-05, 8.206436177715659e-05, 7.912916771601886e-05, 7.234239456010982e-05, 6.207953992998227e-05, 4.888266994385049e-05, 3.34319774992764e-05, 1.6510857676621526e-05, -1.033721559906553e-06, -1.833352325775195e-05, -3.4541932109277695e-05, -4.887529939878732e-05, -6.065074558136985e-05, -6.931859388714656e-05, -7.44878634577617e-05, -7.594375347252935e-05, -7.365621422650293e-05, -6.777937232982367e-05, -5.864188278792426e-05, -4.672884097089991e-05, -3.265621853643097e-05, -1.7139131159638055e-05, -9.555861879562144e-07, 1.5092430658114608e-05, 3.021862721652724e-05, 4.369084854261018e-05, 5.4866432037670165e-05, 6.322276021819562e-05, 6.838160334154963e-05, 7.012601417955011e-05, 6.840917194494978e-05, 6.33547970210202e-05, 5.5249056458706036e-05, 4.452470238902606e-05, 3.1738138204673305e-05, 1.7540660337544978e-05, 2.6453863029018976e-06, -1.220847752847476e-05, -2.629225309647154e-05, -3.892346649081446e-05, -4.949882713845e-05, -5.7522956922184676e-05, -6.2631479522679e-05, -6.460740405600518e-05, -6.339007813949138e-05, -5.9076362958876416e-05, -5.191401214688085e-05, -4.228778925607912e-05, -3.069896047236398e-05, -1.773930671333801e-05, -4.061001163790934e-06, 9.656127076596022e-06, 2.2738311599823646e-05, 3.455087426118553e-05, 4.452894791029394e-05, 5.220438106334768e-05, 5.7227607612730935e-05, 5.9383433836046606e-05, 5.859998782398179e-05, 5.49505784874782e-05, 4.864836228080094e-05, 4.0034225094132125e-05, 2.955851778096985e-05, 1.7757613022695296e-05, 5.226567736826837e-06, -7.410833404719597e-06, -1.9533046724973246e-05, -3.0551273084711283e-05, -3.9937993278726935e-05, -4.7252135118469596e-05, -5.215968849370256e-05, -5.444886483019218e-05, -5.403895920608193e-05, -5.098278052173555e-05, -4.546243144432083e-05, -3.777878373512067e-05, -2.8335274691926315e-05, -1.7616826880839653e-05, -6.165055310702883e-06, 5.449036507343408e-06, 1.6653457350912504e-05, 2.6903333491645753e-05, 3.570735134417191e-05, 4.265120151103474e-05, 4.741702650790103e-05, 4.9797807150753215e-05, 4.970617010258138e-05, 4.7177232772810385e-05, 4.2365318222437054e-05, 3.55349293386098e-05, 2.704638427530881e-05, 1.733692261041142e-05, 6.89827584210434e-06, -3.748159315364319e-06, -1.4077308151172474e-05, -2.3586248062201776e-05, -3.1818632123759016e-05, -3.8386515370802954e-05, -4.2988565837731585e-05, -4.542374881566502e-05, -4.5599957957165316e-05, -4.3537136662052944e-05, -3.9364917029161006e-05, -3.331484549562447e-05, -2.5707699023769237e-05, -1.6936624888330698e-05, -7.446901236107806e-06, 2.28660746870446e-06, 1.1783139598264825e-05, 2.057973324554041e-05, 2.8253718483028933e-05, 3.4442986361682415e-05, 3.8862970541231334e-05, 4.131963214604184e-05, 4.1717838030308485e-05, 4.0064711356535554e-05, 3.6468009056989104e-05, 3.1129500712268054e-05, 2.4333823603228666e-05, 1.643344876356423e-05, 7.830474714864977e-06, -1.0437665878271218e-06, -9.750277968123555e-06, -1.7864056644611992e-05, -2.499478250683751e-05, -3.080553869949654e-05, -3.502863910398446e-05, -3.74778792320285e-05, -3.8056601624703035e-05, -3.676124106277712e-05, -3.368028410477564e-05, -2.8988690246478654e-05, -2.2938149413676e-05, -1.5843706933083013e-05, -8.067427188507281e-06, -8.183177858798283e-19, 7.958842616062611e-06, 1.54200733959442e-05, 2.2024330974090844e-05, 2.7459172997623682e-05, 3.147378811263479e-05, 3.3890464692376554e-05, 3.461236337898299e-05, 3.362712959642522e-05, 3.1006387871457264e-05, 2.6901067030848935e-05, 2.1532890968956053e-05, 1.518255339760799e-05, 8.175096809281968e-06, 8.63355865021731e-07, -6.38975916444906e-06, -1.3229222531663254e-05, -1.9325219909660518e-05, -2.4388995370827615e-05, -2.8186470444779843e-05, -3.0548970244126394e-05, -3.138060128549114e-05, -3.066196586587466e-05, -2.8450016543501988e-05, -2.4874205337255262e-05, -2.0129120457568206e-05, -1.4464001651504077e-05, -8.169738975993823e-06, -1.5639967614333727e-06, 5.024763595429249e-06, 1.1273565178271383e-05, 1.688070551608689e-05, 2.1580261091003194e-05, 2.5154649847536348e-05, 2.7444617444416508e-05, 2.8356236725812778e-05, 2.7864569347002544e-05, 2.601392043288797e-05, 2.291464807058219e-05, 1.873681685538031e-05, 1.3700967429031152e-05, 8.066555892582983e-06, 2.1186572212172905e-06, -3.846408617391717e-06, -9.53579456108855e-06, -1.4674459634989034e-05, -1.9018409147975035e-05, -2.236623186036013e-05, -2.4568362277932465e-05, -2.553366357460618e-05, -2.5233048290829174e-05, -2.369998583162669e-05, -2.102794860547874e-05, -1.7364909581374377e-05, -1.2905288713227492e-05, -7.87970839155605e-06, -2.543119990150444e-06, 2.8380684398143785e-06, 7.999254194146488e-06, 1.2690607036347501e-05, 1.6689109543222003e-05, 1.9809116565738805e-05, 2.1910902432864532e-05, 2.2906828235136345e-05, 2.2764859750168398e-05, 2.150929685740266e-05, 1.92187144421041e-05, 1.6021298506530002e-05, 1.208776575367665e-05, 7.6223432188271545e-06, 2.852226771210553e-06, -1.983939682759228e-06, -6.64795197735657e-06, -1.0913742698903661e-05, -1.4578290574718267e-05, -1.747124406392686e-05, -1.946276461239904e-05, -2.0469278751988895e-05, -2.0456875063246116e-05, -1.944216273841448e-05, -1.7490687241661362e-05, -1.4712933989358135e-05, -1.1258193808316719e-05, -7.306618954316946e-06, -3.059888285861234e-06, 1.2690413768723374e-06, 5.466570655698888e-06, 9.32896182348486e-06, 1.2672181583184283e-05, 1.5340629033744335e-05, 1.7214324543601833e-05, 1.8214215742773376e-05, 1.8305418052477762e-05, 1.7498199667898007e-05, 1.5846755559323356e-05, 1.34458305183216e-05, 1.0425402251712512e-05, 6.943726475583389e-06, 3.1791037145012524e-06, -6.79212178056332e-07, -4.4404819163901266e-06, -7.921878932393156e-06, -1.0957334779959638e-05, -1.3405420759227127e-05, -1.5155882465478498e-05, -1.613453969184775e-05, -1.6306328689097427e-05, -1.5676367183914408e-05, -1.4289034879766405e-05, -1.222512946696952e-05, -9.597290045348927e-06, -6.5439230638730805e-06, -3.2219727472693194e-06, 2.0110621790081495e-07, 3.5557497994886944e-06, 6.678649697278161e-06, 9.42066890274873e-06, 1.1653921319521032e-05, 1.3277694051794242e-05, 1.4222919162421022e-05, 1.445502584829228e-05, 1.3975037290947512e-05, 1.2818905815947801e-05, 1.1055138202209491e-05, 8.780863026913721e-06, 6.11655605098349e-06, 3.1997171845432604e-06, 1.7781452754661586e-07, -2.7991354727419093e-06, -5.585981853073463e-06, -8.0494819485466e-06, -1.0074636520585045e-05, -1.157001588580897e-05, -1.2471822628867812e-05, -1.2746539141517133e-05, -1.2392028111207765e-05, -1.1437066859798506e-05, -9.93937919702148e-06, -7.982276656548493e-06, -5.6700987443036865e-06, -3.1227009458234534e-06, -4.6928943220336805e-07, 2.158102915927884e-06, 4.631153387890663e-06, 6.831486643932294e-06, 8.656304999021813e-06, 1.0023149116022978e-05, 1.087358032236807e-05, 1.1175587133038789e-05, 1.0924682101176586e-05, 1.0143590770894662e-05, 8.880638233677018e-06, 7.206877853604965e-06, 5.2121790758974385e-06, 3.0004514428583207e-06, 6.842709012744308e-07, -1.6208155102503952e-06, -3.8020255033188732e-06, -5.754829544457607e-06, -7.387930509139551e-06, -8.627490387880243e-06, -9.420424248673953e-06, -9.736605534271803e-06, -9.569893336447421e-06, -8.93797096068738e-06, -7.881008059484884e-06, -6.459241376433056e-06, -4.749618710775394e-06, -2.8416864097380312e-06, -8.329383263117052e-07, 1.1761350151573424e-06, 3.0870455702824984e-06, 4.808108769793762e-06, 6.258811936277198e-06, 7.373547759925714e-06, 8.104535481834318e-06, 8.42380632093409e-06, 8.324175723828375e-06, 7.819173333700746e-06, 6.941942046978511e-06, 5.743218025600072e-06, 4.288461695978185e-06, 2.6543375497567467e-06, 9.247138450518833e-07, -8.13615827155445e-07, -2.4752587250986835e-06, -3.980392648372799e-06, -5.258572855382226e-06, -6.251998001971515e-06, -6.9180837272142526e-06, -7.231227300508181e-06, -7.183709385572001e-06, -6.7856844907510094e-06, -6.064296030672267e-06, -5.061973752162885e-06, -3.834014023595955e-06, -2.445581003485131e-06, -9.682810286903987e-07, 5.234977606960456e-07, 1.956307414729963e-06, 3.2612329050607514e-06, 4.377180175652029e-06, 5.253707058727741e-06, 5.853268248756649e-06, 6.152769856271334e-06, 6.144379312900128e-06, 5.835563570144586e-06, 5.248376055533299e-06, 4.418033768160967e-06, 3.390883193787886e-06, 2.221864406237728e-06, 9.716046633911901e-07, -2.9669553214262123e-07, -1.520434580015717e-06, -2.6406769393361174e-06, -3.6049675600224873e-06, -4.369762336864369e-06, -4.902358796243789e-06, -5.182248060009442e-06, -5.201832209422719e-06, -4.9664881771605e-06, -4.493989763432182e-06, -3.8133268844831036e-06, -2.96301050184411e-06, -1.9889384930138476e-06, -9.419523507858685e-07, 1.2478736266530177e-07, 1.1584795629460132e-06, 2.1092746465001255e-06, 2.932656343546114e-06, 3.5915018088417128e-06, 4.057724254380446e-06, 4.313424597057747e-06, 4.351517873146804e-06, 4.175801677774871e-06, 3.8004861835361226e-06, 3.249227802371024e-06, 2.5537140118103707e-06, 1.751888817125291e-06, 8.859187232701515e-07, 2.7149318168432e-20, -8.618755487077578e-07, -1.658085693634348e-06, -2.3513671294494998e-06, -2.910537887146347e-06, -3.3118687952082837e-06, -3.540053739925497e-06, -3.5887314879801124e-06, -3.4605543532961747e-06, -3.166805072396528e-06, -2.726600541791413e-06, -2.1657247089024168e-06, -1.515168492005614e-06, -8.094500003608118e-07, -8.480726876314293e-08, 6.226417781363125e-07, 1.2786815659637796e-06, 1.8526350231695687e-06, 2.318777433174546e-06, 2.6574625735520385e-06, 2.8559143174788915e-06, 2.9086543236189755e-06, 2.8175543320685392e-06, 2.591520569694694e-06, 2.245840050818515e-06, 1.8012269720202312e-06, 1.2826316151404171e-06, 7.178708756327978e-07, 1.3616090654977597e-07, -4.333746801421512e-07, -9.631465900383773e-07, -1.42841849992692e-06, -1.8084441535393125e-06, -2.087366056002793e-06, -2.254845639981795e-06, -2.3063942080625566e-06, -2.2434035145124653e-06, -2.072881898129708e-06, -1.8069151792587945e-06, -1.4618976820202079e-06, -1.0575678288660129e-06, -6.159121426208003e-07, -1.5999307834135834e-07, 2.872369861961488e-07, 7.040755463094683e-07, 1.071107249117631e-06, 1.3720911056225304e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_2_7</value></param>
<param><key>value</key><value>[2.5360584459122038e-06, 3.487747108010808e-06, 4.131898549530888e-06, 4.381189683044795e-06, 4.200715466140537e-06, 3.6149572224530857e-06, 2.7066423626820324e-06, 1.6073286133178044e-06, 4.807484970115183e-07, -4.990267257198866e-07, -1.1716946346496115e-06, -1.413793143001385e-06, -1.1574354630283779e-06, -4.019082666673057e-07, 7.837588213988056e-07, 2.2679435005557025e-06, 3.8726361708540935e-06, 5.396741471486166e-06, 6.643441793130478e-06, 7.447913503710879e-06, 7.701517461100593e-06, 7.368924798356602e-06, 6.495540219475515e-06, 5.203857654123567e-06, 3.6788710531254765e-06, 2.1442381239467068e-06, 8.322361395585176e-07, -4.848425305681303e-08, -3.4288763117729104e-07, 2.6992186263896656e-08, 1.048632384481607e-06, 2.617838390506222e-06, 4.5503520595957525e-06, 6.6050301938958e-06, 8.515706213074736e-06, 1.0027542884927243e-05, 1.0932935765595175e-05, 1.1101912605226971e-05, 1.0502609256946016e-05, 9.20867569220718e-06, 7.392143288598163e-06, 5.302361842041137e-06, 3.23348717756744e-06, 1.4847626061964547e-06, 3.189138624293264e-07, -7.558024606169056e-08, 3.870444515996496e-07, 1.674873828960699e-06, 3.639336227934109e-06, 6.032523288013181e-06, 8.538853762729559e-06, 1.0817079783009831e-05, 1.2547038750199135e-05, 1.3474806110025384e-05, 1.3449838661472313e-05, 1.2448790585040115e-05, 1.0582230061118025e-05, 8.08290315035265e-06, 5.276668161968701e-06, 2.5396650471520843e-06, 2.473326503604767e-07, -1.2778484688169556e-06, -1.8126370378013235e-06, -1.2667322835113737e-06, 3.011328999491525e-07, 2.687412688828772e-06, 5.568226697505452e-06, 8.541217539459467e-06, 1.117941974371206e-05, 1.3089927051623818e-05, 1.3969362044008449e-05, 1.3648288586409763e-05, 1.2118171980546322e-05, 9.53663038671948e-06, 6.209737421158934e-06, 2.5532567633490544e-06, -9.623440746509004e-07, -3.875845322909299e-06, -5.799525752081536e-06, -6.474792826338671e-06, -5.811231858388055e-06, -3.903266588167753e-06, -1.0215422889814363e-06, 2.420368446109933e-06, 5.919910108787008e-06, 8.953147698775865e-06, 1.1046952749893535e-05, 1.1845873814309016e-05, 1.116425028158119e-05, 9.016011063067708e-06, 5.617472197627649e-06, 1.3621241805594764e-06, -3.22975779454282e-06, -7.580255896755261e-06, -1.1132555300719105e-05, -1.3428580132313073e-05, -1.4174715033732355e-05, -1.3286223293107469e-05, -1.0903715519816615e-05, -7.378728241747012e-06, -3.22974483424332e-06, 9.259395596927789e-07, 4.455578618944855e-06, 6.7983487497258466e-06, 7.544707386841765e-06, 6.496542027889518e-06, 3.699358558151289e-06, -5.585849862654868e-07, -5.780804713140242e-06, -1.1326717867632397e-05, -1.6497146134497598e-05, -2.062978091998957e-05, -2.3191614673123695e-05, -2.3855469407862984e-05, -2.2549627828993835e-05, -1.947317832673434e-05, -1.507414344814606e-05, -9.992697414418217e-06, -4.976544914825354e-06, -7.796298291395942e-07, 1.942161588885938e-06, 2.723908437474165e-06, 1.3600700867755222e-06, -2.061580062218127e-06, -7.1659210334473755e-06, -1.333635373157449e-05, -1.9795035768765956e-05, -2.5707091481308453e-05, -3.0294871976366267e-05, -3.294657653896138e-05, -3.330421168357134e-05, -3.1318162655225024e-05, -2.7260211936663836e-05, -2.1692350856028497e-05, -1.539482400403358e-05, -9.26250413613161e-06, -4.183366854704218e-06, -9.154786084764055e-07, 2.048094138729084e-08, -1.5820077123862575e-06, -5.580473043664824e-06, -1.1496203114802483e-05, -1.857375718827825e-05, -2.5879908207571134e-05, -3.2429110433440655e-05, -3.731863762368448e-05, -3.985490548075177e-05, -3.965330688515678e-05, -3.6697259929496795e-05, -3.1347495678346604e-05, -2.4299397409777157e-05, -1.6493220755364746e-05, -8.988768968265504e-06, -2.821178441081429e-06, 1.142639348472585e-06, 2.3269969915418187e-06, 5.32497097083251e-07, -4.029315277875867e-06, -1.0757448762888089e-05, -1.873719520517625e-05, -2.686060543055646e-05, -3.39759535563644e-05, -3.904596815118566e-05, -4.1293220419902354e-05, -4.031225762446411e-05, -3.613242370192893e-05, -2.9221762815723196e-05, -2.043038693955168e-05, -1.0880008630920202e-05, -1.8139825215257588e-06, 5.572178906732006e-06, 1.0296749678673223e-05, 1.173118653241545e-05, 9.693229003460146e-06, 4.480049483390758e-06, -3.164251438647625e-06, -1.2143445019319188e-05, -2.1154301066417247e-05, -2.8862876206403598e-05, -3.408817428862676e-05, -3.596793249016628e-05, -3.4083288483088836e-05, -2.8524485969683155e-05, -1.988733492908068e-05, -9.199914529745001e-06, 2.211750370406662e-06, 1.2901449736091308e-05, 2.150022191926837e-05, 2.6906531275017187e-05, 2.844280970748514e-05, 2.5956152967410162e-05, 1.984831760637462e-05, 1.1029669622075744e-05, 8.021224289223028e-07, -9.313947884947993e-06, -1.778590194589924e-05, -2.3280224922928028e-05, -2.4850000045262277e-05, -2.207221041317098e-05, -1.5115047062863596e-05, -4.724750397144817e-06, 7.867517524573486e-06, 2.1107280190335587e-05, 3.332565393066034e-05, 4.2967523768311366e-05, 4.880778942606412e-05, 5.01256508869119e-05, 4.681221616920084e-05, 3.939541784347966e-05, 2.897748345276341e-05, 1.709218486212194e-05, 5.50014192413073e-06, -4.0504360185877886e-06, -1.0065247806778643e-05, -1.1514270227053203e-05, -7.981508133525494e-06, 2.6753937731882615e-07, 1.2311327736824751e-05, 2.668860361154657e-05, 4.159106902079657e-05, 5.5106982472352684e-05, 6.54829345876351e-05, 7.136796193663031e-05, 7.200603431556374e-05, 6.734955968568102e-05, 5.8076995628653094e-05, 4.551059100776911e-05, 3.144408401567489e-05, 1.7902621038956568e-05, 6.867059710202739e-06, -4.783613916727716e-19, -1.5885552784311585e-06, 2.4969936021079775e-06, 1.1872020877490286e-05, 2.5412409740965813e-05, 4.139787779422477e-05, 5.773971133749001e-05, 7.226285379147157e-05, 8.300415356643498e-05, 8.848613651935011e-05, 8.792787411948666e-05, 8.13631631899625e-05, 6.964815111132339e-05, 5.4355790780391544e-05, 3.756976730073802e-05, 2.1605019355774857e-05, 8.692072697158437e-06, 6.682832349724777e-07, -1.2814037972930237e-06, 3.2023385756474454e-06, 1.3591205060947686e-05, 2.8528662369353697e-05, 4.6004388423170894e-05, 6.362143903970718e-05, 7.892067515058443e-05, 8.97186400834471e-05, 9.441237489227206e-05, 9.220887295668945e-05, 8.324621740030125e-05, 6.858830602141097e-05, 5.009185406379402e-05, 3.0162205803208053e-05, 1.1430030099290889e-05, -3.6078163248021156e-06, -1.2934204278280959e-05, -1.5296587662305683e-05, -1.0390655006631278e-05, 1.0840124105016002e-06, 1.7505792129668407e-05, 3.654110696516e-05, 5.545563544728793e-05, 7.148523582145572e-05, 8.221629104809836e-05, 8.592334779677913e-05, 8.181660814443603e-05, 7.01642784406431e-05, 5.22707705385983e-05, 3.031198139069602e-05, 7.048083716654219e-06, -1.4548163562722038e-05, -3.169767660438083e-05, -4.220037590130232e-05, -4.4746157072950155e-05, -3.910772284143604e-05, -2.6186880859313533e-05, -7.906061910034623e-06, 1.3042326827417128e-05, 3.3556087146280333e-05, 5.054489884059876e-05, 6.13562369835563e-05, 6.414691597456113e-05, 5.814837641082704e-05, 4.37876078649424e-05, 2.2645157514489256e-05, -2.7463177048048237e-06, -2.923739157267846e-05, -5.348673221305944e-05, -7.241823186632246e-05, -8.364790846826509e-05, -8.582122245570645e-05, -7.881345663918182e-05, -6.376324745360762e-05, -4.2932751966873184e-05, -1.9411199900787324e-05, 3.299531499578734e-06, 2.1761699827038683e-05, 3.307614679215476e-05, 3.5288983781356364e-05, 2.7673613658407703e-05, 1.0847593330254313e-05, -1.3294024029164575e-05, -4.182207339908928e-05, -7.116231427062303e-05, -9.757848602021113e-05, -0.00011768403783207759, -0.00012891260848846287, -0.00012988180969841778, -0.00012059881555614993, -0.00010247745376545936, -7.816185097908601e-05, -5.11783582624048e-05, -2.5461527911829762e-05, -4.817601165996166e-06, 7.601354809594341e-06, 9.740161658555735e-06, 9.380555638927035e-07, -1.7961829144041985e-05, -4.470856219995767e-05, -7.59345421101898e-05, -0.000107604093500413, -0.00013555983605328947, -0.00015609293768648058, -0.0001664589362917468, -0.00016526761464774609, -0.0001526913547422737, -0.00013046138337813318, -0.00010164907871512696, -7.026048842817545e-05, -4.069664646522142e-05, -1.7152824511867948e-05, -3.0384376259462442e-06, -4.976402010470338e-07, -1.0098001439473592e-05, -3.07321606669575e-05, -5.974874147796072e-05, -9.329739259555936e-05, -0.00012684319517575204, -0.0001557818177388981, -0.00017607184418011457, -0.0001847978273872286, -0.00018058532441500574, -0.00016380920715164393, -0.00013656383089255542, -0.00010239634138997644, -6.583673530258238e-05, -3.178678889526054e-05, -4.850328423344763e-06, 1.1303873179713264e-05, 1.4458410987572279e-05, 4.170282863924513e-06, -1.8146214642911218e-05, -4.9391124775866047e-05, -8.518446702510118e-05, -0.00012045307084918022, -0.00015011985669843853, -0.00016980232612695545, -0.00017642388411331922, -0.0001686531468294561, -0.0001471084833610803, -0.00011429691221565008, -7.429233664879575e-05, -3.21944899042137e-05, 6.559879693668336e-06, 3.694051338243298e-05, 5.502019848790951e-05, 5.8528043155092746e-05, 4.718150375992991e-05, 2.2749023628421128e-05, -1.1168832315888721e-05, -4.961280865245499e-05, -8.693099516676739e-05, -0.00011754815932363272, -0.00013673373905476183, -0.00014126278983894736, -0.00012987789523322135, -0.00010348584328312427, -6.505906640086323e-05, -1.9251789126428775e-05, 2.8219601517776027e-05, 7.134968473110348e-05, 0.0001046659963321872, 0.00012398733815643936, 0.00012701355444733053, 0.00011366352555342019, 8.611185330664739e-05, 4.851585254073143e-05, 6.466666945925681e-06, -3.376332460902631e-05, -6.607550312764943e-05, -8.538617112208158e-05, -8.833793981466442e-05, -7.378197915386409e-05, -4.296230326872319e-05, 6.27001440989261e-07, 5.1695500587811694e-05, 0.00010386243957327679, 0.00015052082017064095, 0.00018574263958726078, 0.0002051011542789638, 0.00020629609934985638, 0.00018949387595057487, 0.00015733241161797196, 0.00011458610242698342, 6.753334309905767e-05, 2.3109965695766732e-05, -1.2037442502332851e-05, -3.2469200959894806e-05, -3.471471427474171e-05, -1.777261059032753e-05, 1.672296093602199e-05, 6.469646177720279e-05, 0.00012016298569506034, 0.00017602882871869951, 0.00022505356173496693, 0.000260842964053154, 0.0002787372504826635, 0.00027647032402455807, 0.00025450767134316266, 0.00021601264597848058, 0.00016644106653984636, 0.00011281656770734116, 6.278208456933498e-05, 2.3555649022455327e-05, 9.330248644801031e-07, -1.5252990124281496e-06, 1.6991165466606617e-05, 5.440050517790951e-05, 0.00010598203516565263, 0.00016499549383297563, 0.0002235847496194765, 0.00027384483837522566, 0.0003089076781179756, 0.0003238969366066158, 0.0003166199312545359, 0.0002878982631955296, 0.00024148746160790324, 0.00018359297246206552, 0.00012204358063172549, 6.523314368678257e-05, 2.0972840502508916e-05, -4.588946467265487e-06, -7.829894457245246e-06, 1.1820771760540083e-05, 5.177054481464438e-05, 0.00010658546671038494, 0.00016870602848939598, 0.00022946301032789052, 0.00028025679057464004, 0.00031374001991935074, 0.00032484065741300583, 0.00031148374546319246, 0.000274908758001402, 0.00021953508257865906, 0.0001523889077361673, 8.216571586672217e-05, 1.805352803785354e-05, -3.152429417241365e-05, -6.007451520417817e-05, -6.394662341335788e-05, -4.286450348445214e-05, 4.164593408721234e-18, 5.842660539201461e-05, 0.00012396930833347142, 0.00018709366850089282, 0.00023847594275139272, 0.00027028669137507677, 0.00027728304849006236, 0.0002575567923486233, 0.00021283235400915146, 0.00014826847473159432, 7.17862494639121e-05, -6.9897232606308535e-06, -7.803523476468399e-05, -0.00013229901378508657, -0.00016295585373882204, -0.0001663670118432492, -0.00014261277101468295, -9.551949915476143e-05, -3.217218181816861e-05, 3.802573701250367e-05, 0.00010462107456987724, 0.00015753692423459142, 0.00018846186867449433, 0.00019201105169486254, 0.00016649713506922126, 0.00011420115333748981, 4.110117151867598e-05, -4.391008769744076e-05, -0.00013021596532780677, -0.00020691567624453455, -0.0002643182233441621, -0.0002952849317807704, -0.000296235695714131, -0.0002676761068869382, -0.00021416894742287695, -0.00014374792226590216, -6.684832624159753e-05, 5.102831437397981e-06, 6.1247636040207e-05, 9.279559890273958e-05, 9.425334428669885e-05, 6.42137456452474e-05, 5.591676199401263e-06, -7.473144069081172e-05, -0.0001668118202360347, -0.0002589772338978946, -0.00033941189758479595, -0.00039777715574018657, -0.0004266455362085253, -0.0004225492011755705, -0.00038649560883641243, -0.00032387254759669304, -0.00024375169596169144, -0.00015767807781230658, -7.810830720700324e-05, -1.6707723261788487e-05, 1.7260801541851833e-05, 1.8234102753922343e-05, -1.4849317267362494e-05, -7.835773430997506e-05, -0.0001644173898966983, -0.00026195094687864184, -0.0003581663768272847, -0.0004402960475999862, -0.0004973500035703182, -0.000521642214152962, -0.0005098782130517066, -0.00046365056186914444, -0.00038926745764911175, -0.0002969325869344175, -0.0001993812038563192, -0.0001101555535569787, -4.175227877567522e-05, -3.895239387929905e-06, -2.1723344616475515e-06, -3.7226967833703384e-05, -0.00010462079080753028, -0.0001953930768650025, -0.00029724682099185884, -0.0003962045884691179, -0.00047851153067313135, -0.0005325263482518494, -0.0005503405118361115, -0.0005289005348458886, -0.00047047456610016525, -0.00038239240529946983, -0.00027608813252300024, -0.00016556965420022607, -6.551999831572175e-05, 1.0712584298744332e-05, 5.296045492286794e-05, 5.566350228036754e-05, 1.8677033949643373e-05, -5.265635991236195e-05, -0.00014818785712122917, -0.00025431011454202235, -0.00035579304676502943, -0.00043786008609458804, -0.00048822208191268146, -0.0004987894790247083, -0.0004668238398153335, -0.00039536584517918527, -0.0002928737667389214, -0.00017211431986652315, -4.845159128308296e-05, 6.223727541510016e-05, 0.00014573655789718032, 0.00019145903934258968, 0.00019393349066376686, 0.00015360373072326183, 7.682300929445773e-05, -2.4963319447124377e-05, -0.00013674200454261154, -0.0002419606753392145, -0.0003247872518841177, -0.00037229168810881674, -0.0003762502165045589, -0.00033432000782340765, -0.0002504180301912129, -0.0001342430041404441, 1.0507294818179336e-17, 0.0001355065032839775, 0.0002551541256252676, 0.00034384915488772094, 0.00039061676943674684, 0.000390145112760365, 0.0003435662656556815, 0.00025835997075773776, 0.0001473843294661492, 2.7159439923707396e-05, -8.436824282398447e-05, -0.00017027815920300782, -0.00021700988872908056, -0.0002162581222364679, -0.00016616328503005207, -7.162875408539549e-05, 5.62879467906896e-05, 0.00020183436572551727, 0.000346680695656687, 0.000472410669317469, 0.0005630477680824697, 0.0006072695832699537, 0.0006000038702040911, 0.0005431811441667378, 0.0004455331072676927, 0.00032145463046617806, 0.00018907869525719434, 6.781959382351488e-05, -2.428214793326333e-05, -7.305081817321479e-05, -7.015877781668678e-05, -1.432520821254002e-05, 8.84417604538612e-05, 0.00022560132492799312, 0.0003797401732299477, 0.000530916906427592, 0.0006593751022592187, 0.0007482558721676469, 0.0007859373581595719, 0.0007676769164390862, 0.0006963241030462086, 0.0005819970974698663, 0.0004407593223731965, 0.0002924672153312713, 0.00015807762974873185, 5.6779987062327564e-05, 3.34464698426018e-06, 6.054028290236602e-06, 6.550553371198475e-05, 0.0001744586625136435, 0.00031875682179816067, 0.00047920699580572546, 0.0006341679254546762, 0.0007624979480169713, 0.000846461218316108, 0.0008741922210901976, 0.0008413773612119257, 0.0007519153296016157, 0.0006174551090225577, 0.0004558668006211519, 0.0002888445451389998, 0.00013896253949496895, 2.6584157239994965e-05, -3.2953565096249804e-05, -3.1490646506426856e-05, 3.07709960907232e-05, 0.0001452199649065733, 0.0002959418634418398, 0.0004618382372427732, 0.0006194762536324561, 0.0007462846697308123, 0.00082365982234478, 0.0008395559852942824, 0.0007901972276158631, 0.0006806706660427153, 0.0005243088817223907, 0.00034093332942575216, 0.0001541928359074518, -1.1647224710031878e-05, -0.00013502969522960484, -0.00020008772844448686, -0.00019887246889993548, -0.00013251396012492478, -1.1145770258735865e-05, 0.00014740672486368567, 0.00032000572537072003, 0.00048133067321032286, 0.0006073359400033951, 0.0006785637233406305, 0.0006828572950325906, 0.0006170959095470607, 0.0004877053725067526, 0.0003098620509263128, 0.00010548974387347698, -9.968812810257077e-05, -0.0002796434855554253, -0.0004116115451324731, -0.00047924253158271313, -0.00047490050201304257, -0.0004007866373285651, -0.0002687221858650446, -9.860915452009067e-05, 8.423200051765889e-05, 0.00025249188183806837, 0.00038060496444813907, 0.00044827620149590075, 0.0004433153080753982, 0.0003633837914094329, 0.00021640525665134192, 1.9570728909457102e-05, -0.00020293651323299855, -0.00042319612111896276, -0.0006133471615612507, -0.0007494101882912219, -0.0008146099862642586, -0.0008017388172447681, -0.0007142278482206166, -0.0005657666479237378, -0.0003785127482842654, -0.00018012219516094774, 8.924604657247938e-18, 0.0001347228535450995, 0.00020293537818361074, 0.00019249937031418085, 0.00010199655662290752, -5.898009840166196e-05, -0.00027104391483590007, -0.0005075866356492043, -0.0007383648189716041, -0.0009336156072095037, -0.0010681438725441694, -0.0011248171795159578, -0.0010969858849421144, -0.000989485182799399, -0.0008180695003829896, -0.0006073442636989057, -0.0003874642716255039, -0.00019004139176104218, -4.381730468594469e-05, 2.930843402282335e-05, 1.734559191390872e-05, -8.00525740487501e-05, -0.00025143803213723004, -0.000475034088594839, -0.0007216319791041315, -0.0009585325024090707, -0.0011540018022060394, -0.0012816329253837466, -0.0013240148546174169, -0.0012751994654536247, -0.0011416163761168718, -0.0009412971558049321, -0.0007015012670308352, -0.00045505433809012175, -0.0002358910714974627, -7.440672197844833e-05, 6.745704922650475e-06, -4.167271981714293e-06, -0.00010625342110870406, -0.0002860064269043505, -0.0005190488300286233, -0.0007733820239081979, -0.0010137108620256186, -0.001206258195452392, -0.0013234128709882498, -0.00134757359046489, -0.0012736510252580047, -0.0011098752729594707, -0.0008767833351157606, -0.0006045087357051671, -0.00032872974406927824, -8.582259033573791e-05, 9.212402801495045e-05, 0.00018174893921241164, 0.00017169980856124312, 6.429477798519656e-05, -0.00012467734632082283, -0.0003680074296426028, -0.0006307014264166355, -0.0008747162646614015, -0.0010641546687111259, -0.0011702122865244746, -0.0011751935817301273, -0.0010750389192253351, -0.0008800027426332235, -0.0006133727147243917, -0.0003083903866354376, -3.778352493100101e-06, 0.000261523702647537, 0.0004536982742138207, 0.0005487330490723252, 0.0005357995396479964, 0.00041885138489305973, 0.00021620874758809805, -4.1833194700302556e-05, -0.0003170593408867717, -0.0005685125943273306, -0.0007580931996926665, -0.0008558147819712758, -0.0008439937955699861, -0.0007197867962531745, -0.000495713553391397, -0.00019807701755780727, 0.0001365221105515957, 0.0004661144339479506, 0.0007490704883821309, 0.0009498133440501988, 0.0010437495075166225, 0.0010207373416051269, 0.0008866011048667133, 0.0006624689558520913, 0.00038200366543605924, 8.688979869475588e-05, -0.000178819740540348, -0.0003747318696696311, -0.0004696923424489796, -0.00044614585931412876, -0.00030266857356764376, -5.4309355618897825e-05, 0.0002693266433198005, 0.000628008390776813, 0.0009763021371327341, 0.00126975669991225, 0.0014710081741213799, 0.0015549649251624942, 0.0015123568009585142, 0.0013511423021554947, 0.0010955645702779293, 0.0007829655078239739, 0.00045877331285737455, 0.00017033635231200606, -3.956069485866465e-05, -0.0001386120857205242, -0.00010952040611300617, 4.749318031826988e-05, 0.00031456060241907835, 0.0006584588554687798, 0.0010350295342504978, 0.0013951380969956517, 0.0016913689905777574, 0.0018845447339117527, 0.0019491716520860791, 0.0018770585302263498, 0.0016785906627774239, 0.001381468027830124, 0.0010270564816892147, 0.0006648295093327761, 0.0003456503327470273, 0.00011480141984065995, 5.7187476159015205e-06, 3.5295161069370806e-05, 0.00020141215645708144, 0.0004830583347938955, 0.000843041343614459, 0.0012329453602433205, 0.0015996717847883701, 0.00189268309623003, 0.002070960123091936, 0.0021087138447910547, 0.001999062718823552, 0.0017551449127495289, 0.0014084960566833615, 0.0010048873955383897, 0.0005981720751151443, 0.00024296832270920277, -1.2829145816795062e-05, -0.00013468264660332352, -0.0001062721130438149, 6.81002129567787e-05, 0.00036391327739693224, 0.0007396089495159686, 0.0011421405943110585, 0.0015141492476686835, 0.0018017961410805583, 0.001962185138836503, 0.0019693500362336636, 0.001817974029108882, 0.001524311606772244, 0.0011241550091654062, 0.0006681055529043078, 0.00021476643451023847, -0.00017722330812830478, -0.0004572334582917392, -0.0005896618240512908, -0.0005589562933892012, -0.00037193065509200096, -5.703416172764264e-05, 0.0003393564547877759, 0.0007591382600367069, 0.0011403505923226476, 0.0014256462454795837, 0.0015702074160799384, 0.0015480178408324718, 0.0013556110206991434, 0.0010127616114914417, 0.000559991633053869, 5.3208786994218826e-05, -0.00044381857151165605, -0.0008681341423653066, -0.0011662367032840848, -0.0013015069998800755, -0.0012593866558745503, -0.0010495801689103246, -0.0007049457635730505, -0.0002772004227153957, 0.0001700050343060866, 0.0005697134765796363, 0.0008608251227997243, 0.0009965439094230533, 0.0009509414085187018, 0.0007227205787785351, 0.0003356334927957505, -0.00016453227726742625, -0.0007160218083299696, -0.0012494289549067616, -0.0016971429577097297, -0.0020026385318487883, -0.0021283358801156282, -0.0020609330385923386, -0.0018134625861421227, -0.0014237492578104138, -0.0009494552505202591, -0.0004603508859872818, -2.8851300157839432e-05, 0.000279903004411608, 0.00041706362389959395, 0.0003569441905710846, 0.00010077844490297139, -0.00032317903242073953, -0.0008632594835944474, -0.0014512353809550405, -0.0020115154329687357, -0.002471442800015211, -0.002771288389340043, -0.0028725743759423494, -0.002763558877632022, -0.0024611097760498524, -0.002008669078350067, -0.0014705489156767726, -0.0009233102900907397, -0.0004453701840247959, -0.00010625224967952818, 4.3050236854469404e-05, -2.2734207959729247e-05, -0.0002994218666572124, -0.0007536450866609812, -0.001327131874859333, -0.0019444471690803766, -0.0025231679901480675, -0.002985122613608837, -0.0032671596854925156, -0.003329969709739089, -0.0031637188512831926, -0.0027897038962692022, -0.0022577436175197363, -0.0016396349528804421, -0.0010195212671533227, -0.0004824681964237243, -0.00010279395064571872, 6.624772504437715e-05, -5.052379063214184e-18, -0.0002939100959338248, -0.0007762773893773556, -0.001381366397254169, -0.0020256531424820423, -0.002619102131575346, -0.0030774574261158705, -0.0033338689245283604, -0.0033482559956610203, -0.0031130986753851175, -0.0026548155583441257, -0.002030507428571582, -0.0013204473070800304, -0.0006173120927996933, -1.3595853488368448e-05, 0.000411089975386858, 0.0006010848446749151, 0.0005325811798684299, 0.00021723995450884104, -0.0002990220091305673, -0.000941961188800633, -0.001618889975361526, -0.0022312006913125515, -0.002687841886654496, -0.002917907200753689, -0.0028806005138903856, -0.0025711795315146446, -0.002022016327828169, -0.0012985781067982316, -0.0004908168921247125, 0.00029889782308600843, 0.0009696877677924931, 0.0014360292116180062, 0.0016396661521866918, 0.0015579183818772435, 0.0012071989476680756, 0.0006412084330804646, -5.601261727861129e-05, -0.0007812766707502306, -0.0014262014301493764, -0.0018920383881777525, -0.0021033550146967173, -0.0020186742767691612, -0.0016365835908800364, -0.0009964120108634233, -0.00017332461720798165, 0.0007315607508644462, 0.0016047395765781403, 0.002335749799385667, 0.0028323691803961992, 0.003033493645489216, 0.002917899750173092, 0.0025076393503695726, 0.0018655334133654833, 0.0010870397090911865, 0.0002875372301787138, -0.00041328169754706323, -0.0009078056900762022, -0.0011154459789395332, -0.000994054600596428, -0.0005462105036713183, 0.00018055716645903885, 0.0010997132631018758, 0.002097092568874359, 0.003046214347705245, 0.0038254878018051386, 0.004334963392466307, 0.004510334227234125, 0.004332226701080799, 0.0038294389378279448, 0.003075612476095557, 0.002179700182750821, 0.0012714588083326817, 0.00048389320727437735, -6.498090806417167e-05, -0.0002885623252950609, -0.0001439970947103575, 0.0003613278968259692, 0.0011701014591380954, 0.002182264346629381, 0.003268154338002205, 0.004285898525267839, 0.00510072335600853, 0.005603561643511057, 0.005726389121264219, 0.005452143494039774, 0.0048177847638726234, 0.00390998087823391, 0.0028539106715470552, 0.0017966071609407663, 0.0008870692690834403, 0.00025580739020369947, -3.369013484189054e-06, 0.0001532076275907457, 0.0007123093237169087, 0.0016047715907916427, 0.002714148722589016, 0.0038919930811971426, 0.004977759439498186, 0.005820676684379578, 0.0063006081618368626, 0.006345031317323446, 0.00593973696231842, 0.0051316930912435055, 0.004023545887321234, 0.0027603909838944674, 0.0015105066122487187, 0.0004425932129379362, -0.00029741102480329573, -0.0006067604408599436, -0.00044073493336327374, 0.00018025471945293248, 0.001172388787381351, 0.0023988981265574694, 0.003687971504405141, 0.004855775274336338, 0.005731517449021339, 0.006181144155561924, 0.006126400548964739, 0.005556558258831501, 0.00453107338398695, 0.0031726493034511805, 0.0016514951130375266, 0.00016277788381557912, -0.00109975622035563, -0.001970441546291113, -0.002334980061277747, -0.002147102262824774, -0.0014361887006089091, -0.00030464824521914124, 0.0010847862577065825, 0.0025302856229245663, 0.003817925928160548, 0.0047508729621768, 0.005176779814064503, 0.005009617656469345, 0.004242824390530586, 0.002951802220195532, 0.0012852126965299249, -0.0005539658013731241, -0.0023352261632680893, -0.0038316496647894382, -0.004851175472140312, -0.005263740196824074, -0.005020474083721638, -0.004162163008004427, -0.0028155744075775146, -0.0011779058258980513, 0.0005087830941192806, 0.0019898624159395695, 0.0030328736174851656, 0.0034600100480020046, 0.00317384023219347, 0.0021725869737565517, 0.0005526344175450504, -0.0015023781452327967, -0.00374470092356205, -0.0058949715457856655, -0.007679841946810484, -0.00886970292776823, -0.009311343543231487, -0.00895095057785511, -0.007844055071473122, -0.00615072064101696, -0.0041162846609950066, -0.0020398821216076612, -0.00023475424677599221, 0.001014446490444243, 0.001491597038693726, 0.0010807522339746356, -0.00021505374752450734, -0.002270786091685295, -0.004853020887821913, -0.007648811675608158, -0.010306300595402718, -0.012481877580285072, -0.013887643814086914, -0.014332701452076435, -0.013752451166510582, -0.012221521697938442, -0.009948067367076874, -0.007249595131725073, -0.004513038322329521, -0.0021439872216433287, -0.0005116353859193623, 0.00010321416630176827, -0.00045010409667156637, -0.0021666481625288725, -0.004880718421190977, -0.008282458409667015, -0.01195475272834301, -0.015426166355609894, -0.018233368173241615, -0.019984934478998184, -0.0204179510474205, -0.019439486786723137, -0.01714668981730938, -0.013821935281157494, -0.00990261323750019, -0.005928525701165199, -0.0024730199947953224, -6.633735029026866e-05, 0.0008788559935055673, 0.0001297056005569175, -0.0023257355205714703, -0.006265054922550917, -0.011248827911913395, -0.016668016090989113, -0.02181667648255825, -0.02598170004785061, -0.028538696467876434, -0.029041754081845284, -0.027294976636767387, -0.02339550293982029, -0.017740728333592415, -0.010996681638062, -0.004029314499348402, 0.0021948760841041803, 0.006728183012455702, 0.008767309598624706, 0.007770070340484381, 0.0035482775419950485, -0.0036759325303137302, -0.013259341940283775, -0.024176429957151413, -0.03510598838329315, -0.044558145105838776, -0.05102931335568428, -0.05316881835460663, -0.04993890970945358, -0.0407499261200428, -0.025554470717906952, -0.004888597875833511, 0.020146619528532028, 0.04796320199966431, 0.07661760598421097, 0.10398291051387787, 0.12794463336467743, 0.14660018682479858, 0.15844114124774933, 0.1624993085861206, 0.15844114124774933, 0.14660018682479858, 0.12794463336467743, 0.10398291051387787, 0.07661760598421097, 0.04796320199966431, 0.020146619528532028, -0.004888597875833511, -0.025554470717906952, -0.0407499261200428, -0.04993890970945358, -0.05316881835460663, -0.05102931335568428, -0.044558145105838776, -0.03510598838329315, -0.024176429957151413, -0.013259341940283775, -0.0036759325303137302, 0.0035482775419950485, 0.007770070340484381, 0.008767309598624706, 0.006728183012455702, 0.0021948760841041803, -0.004029314499348402, -0.010996681638062, -0.017740728333592415, -0.02339550293982029, -0.027294976636767387, -0.029041754081845284, -0.028538696467876434, -0.02598170004785061, -0.02181667648255825, -0.016668016090989113, -0.011248827911913395, -0.006265054922550917, -0.0023257355205714703, 0.0001297056005569175, 0.0008788559935055673, -6.633735029026866e-05, -0.0024730199947953224, -0.005928525701165199, -0.00990261323750019, -0.013821935281157494, -0.01714668981730938, -0.019439486786723137, -0.0204179510474205, -0.019984934478998184, -0.018233368173241615, -0.015426166355609894, -0.01195475272834301, -0.008282458409667015, -0.004880718421190977, -0.0021666481625288725, -0.00045010409667156637, 0.00010321416630176827, -0.0005116353859193623, -0.0021439872216433287, -0.004513038322329521, -0.007249595131725073, -0.009948067367076874, -0.012221521697938442, -0.013752451166510582, -0.014332701452076435, -0.013887643814086914, -0.012481877580285072, -0.010306300595402718, -0.007648811675608158, -0.004853020887821913, -0.002270786091685295, -0.00021505374752450734, 0.0010807522339746356, 0.001491597038693726, 0.001014446490444243, -0.00023475424677599221, -0.0020398821216076612, -0.0041162846609950066, -0.00615072064101696, -0.007844055071473122, -0.00895095057785511, -0.009311343543231487, -0.00886970292776823, -0.007679841946810484, -0.0058949715457856655, -0.00374470092356205, -0.0015023781452327967, 0.0005526344175450504, 0.0021725869737565517, 0.00317384023219347, 0.0034600100480020046, 0.0030328736174851656, 0.0019898624159395695, 0.0005087830941192806, -0.0011779058258980513, -0.0028155744075775146, -0.004162163008004427, -0.005020474083721638, -0.005263740196824074, -0.004851175472140312, -0.0038316496647894382, -0.0023352261632680893, -0.0005539658013731241, 0.0012852126965299249, 0.002951802220195532, 0.004242824390530586, 0.005009617656469345, 0.005176779814064503, 0.0047508729621768, 0.003817925928160548, 0.0025302856229245663, 0.0010847862577065825, -0.00030464824521914124, -0.0014361887006089091, -0.002147102262824774, -0.002334980061277747, -0.001970441546291113, -0.00109975622035563, 0.00016277788381557912, 0.0016514951130375266, 0.0031726493034511805, 0.00453107338398695, 0.005556558258831501, 0.006126400548964739, 0.006181144155561924, 0.005731517449021339, 0.004855775274336338, 0.003687971504405141, 0.0023988981265574694, 0.001172388787381351, 0.00018025471945293248, -0.00044073493336327374, -0.0006067604408599436, -0.00029741102480329573, 0.0004425932129379362, 0.0015105066122487187, 0.0027603909838944674, 0.004023545887321234, 0.0051316930912435055, 0.00593973696231842, 0.006345031317323446, 0.0063006081618368626, 0.005820676684379578, 0.004977759439498186, 0.0038919930811971426, 0.002714148722589016, 0.0016047715907916427, 0.0007123093237169087, 0.0001532076275907457, -3.369013484189054e-06, 0.00025580739020369947, 0.0008870692690834403, 0.0017966071609407663, 0.0028539106715470552, 0.00390998087823391, 0.0048177847638726234, 0.005452143494039774, 0.005726389121264219, 0.005603561643511057, 0.00510072335600853, 0.004285898525267839, 0.003268154338002205, 0.002182264346629381, 0.0011701014591380954, 0.0003613278968259692, -0.0001439970947103575, -0.0002885623252950609, -6.498090806417167e-05, 0.00048389320727437735, 0.0012714588083326817, 0.002179700182750821, 0.003075612476095557, 0.0038294389378279448, 0.004332226701080799, 0.004510334227234125, 0.004334963392466307, 0.0038254878018051386, 0.003046214347705245, 0.002097092568874359, 0.0010997132631018758, 0.00018055716645903885, -0.0005462105036713183, -0.000994054600596428, -0.0011154459789395332, -0.0009078056900762022, -0.00041328169754706323, 0.0002875372301787138, 0.0010870397090911865, 0.0018655334133654833, 0.0025076393503695726, 0.002917899750173092, 0.003033493645489216, 0.0028323691803961992, 0.002335749799385667, 0.0016047395765781403, 0.0007315607508644462, -0.00017332461720798165, -0.0009964120108634233, -0.0016365835908800364, -0.0020186742767691612, -0.0021033550146967173, -0.0018920383881777525, -0.0014262014301493764, -0.0007812766707502306, -5.601261727861129e-05, 0.0006412084330804646, 0.0012071989476680756, 0.0015579183818772435, 0.0016396661521866918, 0.0014360292116180062, 0.0009696877677924931, 0.00029889782308600843, -0.0004908168921247125, -0.0012985781067982316, -0.002022016327828169, -0.0025711795315146446, -0.0028806005138903856, -0.002917907200753689, -0.002687841886654496, -0.0022312006913125515, -0.001618889975361526, -0.000941961188800633, -0.0002990220091305673, 0.00021723995450884104, 0.0005325811798684299, 0.0006010848446749151, 0.000411089975386858, -1.3595853488368448e-05, -0.0006173120927996933, -0.0013204473070800304, -0.002030507428571582, -0.0026548155583441257, -0.0031130986753851175, -0.0033482559956610203, -0.0033338689245283604, -0.0030774574261158705, -0.002619102131575346, -0.0020256531424820423, -0.001381366397254169, -0.0007762773893773556, -0.0002939100959338248, -5.052379063214184e-18, 6.624772504437715e-05, -0.00010279395064571872, -0.0004824681964237243, -0.0010195212671533227, -0.0016396349528804421, -0.0022577436175197363, -0.0027897038962692022, -0.0031637188512831926, -0.003329969709739089, -0.0032671596854925156, -0.002985122613608837, -0.0025231679901480675, -0.0019444471690803766, -0.001327131874859333, -0.0007536450866609812, -0.0002994218666572124, -2.2734207959729247e-05, 4.3050236854469404e-05, -0.00010625224967952818, -0.0004453701840247959, -0.0009233102900907397, -0.0014705489156767726, -0.002008669078350067, -0.0024611097760498524, -0.002763558877632022, -0.0028725743759423494, -0.002771288389340043, -0.002471442800015211, -0.0020115154329687357, -0.0014512353809550405, -0.0008632594835944474, -0.00032317903242073953, 0.00010077844490297139, 0.0003569441905710846, 0.00041706362389959395, 0.000279903004411608, -2.8851300157839432e-05, -0.0004603508859872818, -0.0009494552505202591, -0.0014237492578104138, -0.0018134625861421227, -0.0020609330385923386, -0.0021283358801156282, -0.0020026385318487883, -0.0016971429577097297, -0.0012494289549067616, -0.0007160218083299696, -0.00016453227726742625, 0.0003356334927957505, 0.0007227205787785351, 0.0009509414085187018, 0.0009965439094230533, 0.0008608251227997243, 0.0005697134765796363, 0.0001700050343060866, -0.0002772004227153957, -0.0007049457635730505, -0.0010495801689103246, -0.0012593866558745503, -0.0013015069998800755, -0.0011662367032840848, -0.0008681341423653066, -0.00044381857151165605, 5.3208786994218826e-05, 0.000559991633053869, 0.0010127616114914417, 0.0013556110206991434, 0.0015480178408324718, 0.0015702074160799384, 0.0014256462454795837, 0.0011403505923226476, 0.0007591382600367069, 0.0003393564547877759, -5.703416172764264e-05, -0.00037193065509200096, -0.0005589562933892012, -0.0005896618240512908, -0.0004572334582917392, -0.00017722330812830478, 0.00021476643451023847, 0.0006681055529043078, 0.0011241550091654062, 0.001524311606772244, 0.001817974029108882, 0.0019693500362336636, 0.001962185138836503, 0.0018017961410805583, 0.0015141492476686835, 0.0011421405943110585, 0.0007396089495159686, 0.00036391327739693224, 6.81002129567787e-05, -0.0001062721130438149, -0.00013468264660332352, -1.2829145816795062e-05, 0.00024296832270920277, 0.0005981720751151443, 0.0010048873955383897, 0.0014084960566833615, 0.0017551449127495289, 0.001999062718823552, 0.0021087138447910547, 0.002070960123091936, 0.00189268309623003, 0.0015996717847883701, 0.0012329453602433205, 0.000843041343614459, 0.0004830583347938955, 0.00020141215645708144, 3.5295161069370806e-05, 5.7187476159015205e-06, 0.00011480141984065995, 0.0003456503327470273, 0.0006648295093327761, 0.0010270564816892147, 0.001381468027830124, 0.0016785906627774239, 0.0018770585302263498, 0.0019491716520860791, 0.0018845447339117527, 0.0016913689905777574, 0.0013951380969956517, 0.0010350295342504978, 0.0006584588554687798, 0.00031456060241907835, 4.749318031826988e-05, -0.00010952040611300617, -0.0001386120857205242, -3.956069485866465e-05, 0.00017033635231200606, 0.00045877331285737455, 0.0007829655078239739, 0.0010955645702779293, 0.0013511423021554947, 0.0015123568009585142, 0.0015549649251624942, 0.0014710081741213799, 0.00126975669991225, 0.0009763021371327341, 0.000628008390776813, 0.0002693266433198005, -5.4309355618897825e-05, -0.00030266857356764376, -0.00044614585931412876, -0.0004696923424489796, -0.0003747318696696311, -0.000178819740540348, 8.688979869475588e-05, 0.00038200366543605924, 0.0006624689558520913, 0.0008866011048667133, 0.0010207373416051269, 0.0010437495075166225, 0.0009498133440501988, 0.0007490704883821309, 0.0004661144339479506, 0.0001365221105515957, -0.00019807701755780727, -0.000495713553391397, -0.0007197867962531745, -0.0008439937955699861, -0.0008558147819712758, -0.0007580931996926665, -0.0005685125943273306, -0.0003170593408867717, -4.1833194700302556e-05, 0.00021620874758809805, 0.00041885138489305973, 0.0005357995396479964, 0.0005487330490723252, 0.0004536982742138207, 0.000261523702647537, -3.778352493100101e-06, -0.0003083903866354376, -0.0006133727147243917, -0.0008800027426332235, -0.0010750389192253351, -0.0011751935817301273, -0.0011702122865244746, -0.0010641546687111259, -0.0008747162646614015, -0.0006307014264166355, -0.0003680074296426028, -0.00012467734632082283, 6.429477798519656e-05, 0.00017169980856124312, 0.00018174893921241164, 9.212402801495045e-05, -8.582259033573791e-05, -0.00032872974406927824, -0.0006045087357051671, -0.0008767833351157606, -0.0011098752729594707, -0.0012736510252580047, -0.00134757359046489, -0.0013234128709882498, -0.001206258195452392, -0.0010137108620256186, -0.0007733820239081979, -0.0005190488300286233, -0.0002860064269043505, -0.00010625342110870406, -4.167271981714293e-06, 6.745704922650475e-06, -7.440672197844833e-05, -0.0002358910714974627, -0.00045505433809012175, -0.0007015012670308352, -0.0009412971558049321, -0.0011416163761168718, -0.0012751994654536247, -0.0013240148546174169, -0.0012816329253837466, -0.0011540018022060394, -0.0009585325024090707, -0.0007216319791041315, -0.000475034088594839, -0.00025143803213723004, -8.00525740487501e-05, 1.734559191390872e-05, 2.930843402282335e-05, -4.381730468594469e-05, -0.00019004139176104218, -0.0003874642716255039, -0.0006073442636989057, -0.0008180695003829896, -0.000989485182799399, -0.0010969858849421144, -0.0011248171795159578, -0.0010681438725441694, -0.0009336156072095037, -0.0007383648189716041, -0.0005075866356492043, -0.00027104391483590007, -5.898009840166196e-05, 0.00010199655662290752, 0.00019249937031418085, 0.00020293537818361074, 0.0001347228535450995, 8.924604657247938e-18, -0.00018012219516094774, -0.0003785127482842654, -0.0005657666479237378, -0.0007142278482206166, -0.0008017388172447681, -0.0008146099862642586, -0.0007494101882912219, -0.0006133471615612507, -0.00042319612111896276, -0.00020293651323299855, 1.9570728909457102e-05, 0.00021640525665134192, 0.0003633837914094329, 0.0004433153080753982, 0.00044827620149590075, 0.00038060496444813907, 0.00025249188183806837, 8.423200051765889e-05, -9.860915452009067e-05, -0.0002687221858650446, -0.0004007866373285651, -0.00047490050201304257, -0.00047924253158271313, -0.0004116115451324731, -0.0002796434855554253, -9.968812810257077e-05, 0.00010548974387347698, 0.0003098620509263128, 0.0004877053725067526, 0.0006170959095470607, 0.0006828572950325906, 0.0006785637233406305, 0.0006073359400033951, 0.00048133067321032286, 0.00032000572537072003, 0.00014740672486368567, -1.1145770258735865e-05, -0.00013251396012492478, -0.00019887246889993548, -0.00020008772844448686, -0.00013502969522960484, -1.1647224710031878e-05, 0.0001541928359074518, 0.00034093332942575216, 0.0005243088817223907, 0.0006806706660427153, 0.0007901972276158631, 0.0008395559852942824, 0.00082365982234478, 0.0007462846697308123, 0.0006194762536324561, 0.0004618382372427732, 0.0002959418634418398, 0.0001452199649065733, 3.07709960907232e-05, -3.1490646506426856e-05, -3.2953565096249804e-05, 2.6584157239994965e-05, 0.00013896253949496895, 0.0002888445451389998, 0.0004558668006211519, 0.0006174551090225577, 0.0007519153296016157, 0.0008413773612119257, 0.0008741922210901976, 0.000846461218316108, 0.0007624979480169713, 0.0006341679254546762, 0.00047920699580572546, 0.00031875682179816067, 0.0001744586625136435, 6.550553371198475e-05, 6.054028290236602e-06, 3.34464698426018e-06, 5.6779987062327564e-05, 0.00015807762974873185, 0.0002924672153312713, 0.0004407593223731965, 0.0005819970974698663, 0.0006963241030462086, 0.0007676769164390862, 0.0007859373581595719, 0.0007482558721676469, 0.0006593751022592187, 0.000530916906427592, 0.0003797401732299477, 0.00022560132492799312, 8.84417604538612e-05, -1.432520821254002e-05, -7.015877781668678e-05, -7.305081817321479e-05, -2.428214793326333e-05, 6.781959382351488e-05, 0.00018907869525719434, 0.00032145463046617806, 0.0004455331072676927, 0.0005431811441667378, 0.0006000038702040911, 0.0006072695832699537, 0.0005630477680824697, 0.000472410669317469, 0.000346680695656687, 0.00020183436572551727, 5.62879467906896e-05, -7.162875408539549e-05, -0.00016616328503005207, -0.0002162581222364679, -0.00021700988872908056, -0.00017027815920300782, -8.436824282398447e-05, 2.7159439923707396e-05, 0.0001473843294661492, 0.00025835997075773776, 0.0003435662656556815, 0.000390145112760365, 0.00039061676943674684, 0.00034384915488772094, 0.0002551541256252676, 0.0001355065032839775, 1.0507294818179336e-17, -0.0001342430041404441, -0.0002504180301912129, -0.00033432000782340765, -0.0003762502165045589, -0.00037229168810881674, -0.0003247872518841177, -0.0002419606753392145, -0.00013674200454261154, -2.4963319447124377e-05, 7.682300929445773e-05, 0.00015360373072326183, 0.00019393349066376686, 0.00019145903934258968, 0.00014573655789718032, 6.223727541510016e-05, -4.845159128308296e-05, -0.00017211431986652315, -0.0002928737667389214, -0.00039536584517918527, -0.0004668238398153335, -0.0004987894790247083, -0.00048822208191268146, -0.00043786008609458804, -0.00035579304676502943, -0.00025431011454202235, -0.00014818785712122917, -5.265635991236195e-05, 1.8677033949643373e-05, 5.566350228036754e-05, 5.296045492286794e-05, 1.0712584298744332e-05, -6.551999831572175e-05, -0.00016556965420022607, -0.00027608813252300024, -0.00038239240529946983, -0.00047047456610016525, -0.0005289005348458886, -0.0005503405118361115, -0.0005325263482518494, -0.00047851153067313135, -0.0003962045884691179, -0.00029724682099185884, -0.0001953930768650025, -0.00010462079080753028, -3.7226967833703384e-05, -2.1723344616475515e-06, -3.895239387929905e-06, -4.175227877567522e-05, -0.0001101555535569787, -0.0001993812038563192, -0.0002969325869344175, -0.00038926745764911175, -0.00046365056186914444, -0.0005098782130517066, -0.000521642214152962, -0.0004973500035703182, -0.0004402960475999862, -0.0003581663768272847, -0.00026195094687864184, -0.0001644173898966983, -7.835773430997506e-05, -1.4849317267362494e-05, 1.8234102753922343e-05, 1.7260801541851833e-05, -1.6707723261788487e-05, -7.810830720700324e-05, -0.00015767807781230658, -0.00024375169596169144, -0.00032387254759669304, -0.00038649560883641243, -0.0004225492011755705, -0.0004266455362085253, -0.00039777715574018657, -0.00033941189758479595, -0.0002589772338978946, -0.0001668118202360347, -7.473144069081172e-05, 5.591676199401263e-06, 6.42137456452474e-05, 9.425334428669885e-05, 9.279559890273958e-05, 6.1247636040207e-05, 5.102831437397981e-06, -6.684832624159753e-05, -0.00014374792226590216, -0.00021416894742287695, -0.0002676761068869382, -0.000296235695714131, -0.0002952849317807704, -0.0002643182233441621, -0.00020691567624453455, -0.00013021596532780677, -4.391008769744076e-05, 4.110117151867598e-05, 0.00011420115333748981, 0.00016649713506922126, 0.00019201105169486254, 0.00018846186867449433, 0.00015753692423459142, 0.00010462107456987724, 3.802573701250367e-05, -3.217218181816861e-05, -9.551949915476143e-05, -0.00014261277101468295, -0.0001663670118432492, -0.00016295585373882204, -0.00013229901378508657, -7.803523476468399e-05, -6.9897232606308535e-06, 7.17862494639121e-05, 0.00014826847473159432, 0.00021283235400915146, 0.0002575567923486233, 0.00027728304849006236, 0.00027028669137507677, 0.00023847594275139272, 0.00018709366850089282, 0.00012396930833347142, 5.842660539201461e-05, 4.164593408721234e-18, -4.286450348445214e-05, -6.394662341335788e-05, -6.007451520417817e-05, -3.152429417241365e-05, 1.805352803785354e-05, 8.216571586672217e-05, 0.0001523889077361673, 0.00021953508257865906, 0.000274908758001402, 0.00031148374546319246, 0.00032484065741300583, 0.00031374001991935074, 0.00028025679057464004, 0.00022946301032789052, 0.00016870602848939598, 0.00010658546671038494, 5.177054481464438e-05, 1.1820771760540083e-05, -7.829894457245246e-06, -4.588946467265487e-06, 2.0972840502508916e-05, 6.523314368678257e-05, 0.00012204358063172549, 0.00018359297246206552, 0.00024148746160790324, 0.0002878982631955296, 0.0003166199312545359, 0.0003238969366066158, 0.0003089076781179756, 0.00027384483837522566, 0.0002235847496194765, 0.00016499549383297563, 0.00010598203516565263, 5.440050517790951e-05, 1.6991165466606617e-05, -1.5252990124281496e-06, 9.330248644801031e-07, 2.3555649022455327e-05, 6.278208456933498e-05, 0.00011281656770734116, 0.00016644106653984636, 0.00021601264597848058, 0.00025450767134316266, 0.00027647032402455807, 0.0002787372504826635, 0.000260842964053154, 0.00022505356173496693, 0.00017602882871869951, 0.00012016298569506034, 6.469646177720279e-05, 1.672296093602199e-05, -1.777261059032753e-05, -3.471471427474171e-05, -3.2469200959894806e-05, -1.2037442502332851e-05, 2.3109965695766732e-05, 6.753334309905767e-05, 0.00011458610242698342, 0.00015733241161797196, 0.00018949387595057487, 0.00020629609934985638, 0.0002051011542789638, 0.00018574263958726078, 0.00015052082017064095, 0.00010386243957327679, 5.1695500587811694e-05, 6.27001440989261e-07, -4.296230326872319e-05, -7.378197915386409e-05, -8.833793981466442e-05, -8.538617112208158e-05, -6.607550312764943e-05, -3.376332460902631e-05, 6.466666945925681e-06, 4.851585254073143e-05, 8.611185330664739e-05, 0.00011366352555342019, 0.00012701355444733053, 0.00012398733815643936, 0.0001046659963321872, 7.134968473110348e-05, 2.8219601517776027e-05, -1.9251789126428775e-05, -6.505906640086323e-05, -0.00010348584328312427, -0.00012987789523322135, -0.00014126278983894736, -0.00013673373905476183, -0.00011754815932363272, -8.693099516676739e-05, -4.961280865245499e-05, -1.1168832315888721e-05, 2.2749023628421128e-05, 4.718150375992991e-05, 5.8528043155092746e-05, 5.502019848790951e-05, 3.694051338243298e-05, 6.559879693668336e-06, -3.21944899042137e-05, -7.429233664879575e-05, -0.00011429691221565008, -0.0001471084833610803, -0.0001686531468294561, -0.00017642388411331922, -0.00016980232612695545, -0.00015011985669843853, -0.00012045307084918022, -8.518446702510118e-05, -4.9391124775866047e-05, -1.8146214642911218e-05, 4.170282863924513e-06, 1.4458410987572279e-05, 1.1303873179713264e-05, -4.850328423344763e-06, -3.178678889526054e-05, -6.583673530258238e-05, -0.00010239634138997644, -0.00013656383089255542, -0.00016380920715164393, -0.00018058532441500574, -0.0001847978273872286, -0.00017607184418011457, -0.0001557818177388981, -0.00012684319517575204, -9.329739259555936e-05, -5.974874147796072e-05, -3.07321606669575e-05, -1.0098001439473592e-05, -4.976402010470338e-07, -3.0384376259462442e-06, -1.7152824511867948e-05, -4.069664646522142e-05, -7.026048842817545e-05, -0.00010164907871512696, -0.00013046138337813318, -0.0001526913547422737, -0.00016526761464774609, -0.0001664589362917468, -0.00015609293768648058, -0.00013555983605328947, -0.000107604093500413, -7.59345421101898e-05, -4.470856219995767e-05, -1.7961829144041985e-05, 9.380555638927035e-07, 9.740161658555735e-06, 7.601354809594341e-06, -4.817601165996166e-06, -2.5461527911829762e-05, -5.11783582624048e-05, -7.816185097908601e-05, -0.00010247745376545936, -0.00012059881555614993, -0.00012988180969841778, -0.00012891260848846287, -0.00011768403783207759, -9.757848602021113e-05, -7.116231427062303e-05, -4.182207339908928e-05, -1.3294024029164575e-05, 1.0847593330254313e-05, 2.7673613658407703e-05, 3.5288983781356364e-05, 3.307614679215476e-05, 2.1761699827038683e-05, 3.299531499578734e-06, -1.9411199900787324e-05, -4.2932751966873184e-05, -6.376324745360762e-05, -7.881345663918182e-05, -8.582122245570645e-05, -8.364790846826509e-05, -7.241823186632246e-05, -5.348673221305944e-05, -2.923739157267846e-05, -2.7463177048048237e-06, 2.2645157514489256e-05, 4.37876078649424e-05, 5.814837641082704e-05, 6.414691597456113e-05, 6.13562369835563e-05, 5.054489884059876e-05, 3.3556087146280333e-05, 1.3042326827417128e-05, -7.906061910034623e-06, -2.6186880859313533e-05, -3.910772284143604e-05, -4.4746157072950155e-05, -4.220037590130232e-05, -3.169767660438083e-05, -1.4548163562722038e-05, 7.048083716654219e-06, 3.031198139069602e-05, 5.22707705385983e-05, 7.01642784406431e-05, 8.181660814443603e-05, 8.592334779677913e-05, 8.221629104809836e-05, 7.148523582145572e-05, 5.545563544728793e-05, 3.654110696516e-05, 1.7505792129668407e-05, 1.0840124105016002e-06, -1.0390655006631278e-05, -1.5296587662305683e-05, -1.2934204278280959e-05, -3.6078163248021156e-06, 1.1430030099290889e-05, 3.0162205803208053e-05, 5.009185406379402e-05, 6.858830602141097e-05, 8.324621740030125e-05, 9.220887295668945e-05, 9.441237489227206e-05, 8.97186400834471e-05, 7.892067515058443e-05, 6.362143903970718e-05, 4.6004388423170894e-05, 2.8528662369353697e-05, 1.3591205060947686e-05, 3.2023385756474454e-06, -1.2814037972930237e-06, 6.682832349724777e-07, 8.692072697158437e-06, 2.1605019355774857e-05, 3.756976730073802e-05, 5.4355790780391544e-05, 6.964815111132339e-05, 8.13631631899625e-05, 8.792787411948666e-05, 8.848613651935011e-05, 8.300415356643498e-05, 7.226285379147157e-05, 5.773971133749001e-05, 4.139787779422477e-05, 2.5412409740965813e-05, 1.1872020877490286e-05, 2.4969936021079775e-06, -1.5885552784311585e-06, -4.783613916727716e-19, 6.867059710202739e-06, 1.7902621038956568e-05, 3.144408401567489e-05, 4.551059100776911e-05, 5.8076995628653094e-05, 6.734955968568102e-05, 7.200603431556374e-05, 7.136796193663031e-05, 6.54829345876351e-05, 5.5106982472352684e-05, 4.159106902079657e-05, 2.668860361154657e-05, 1.2311327736824751e-05, 2.6753937731882615e-07, -7.981508133525494e-06, -1.1514270227053203e-05, -1.0065247806778643e-05, -4.0504360185877886e-06, 5.50014192413073e-06, 1.709218486212194e-05, 2.897748345276341e-05, 3.939541784347966e-05, 4.681221616920084e-05, 5.01256508869119e-05, 4.880778942606412e-05, 4.2967523768311366e-05, 3.332565393066034e-05, 2.1107280190335587e-05, 7.867517524573486e-06, -4.724750397144817e-06, -1.5115047062863596e-05, -2.207221041317098e-05, -2.4850000045262277e-05, -2.3280224922928028e-05, -1.778590194589924e-05, -9.313947884947993e-06, 8.021224289223028e-07, 1.1029669622075744e-05, 1.984831760637462e-05, 2.5956152967410162e-05, 2.844280970748514e-05, 2.6906531275017187e-05, 2.150022191926837e-05, 1.2901449736091308e-05, 2.211750370406662e-06, -9.199914529745001e-06, -1.988733492908068e-05, -2.8524485969683155e-05, -3.4083288483088836e-05, -3.596793249016628e-05, -3.408817428862676e-05, -2.8862876206403598e-05, -2.1154301066417247e-05, -1.2143445019319188e-05, -3.164251438647625e-06, 4.480049483390758e-06, 9.693229003460146e-06, 1.173118653241545e-05, 1.0296749678673223e-05, 5.572178906732006e-06, -1.8139825215257588e-06, -1.0880008630920202e-05, -2.043038693955168e-05, -2.9221762815723196e-05, -3.613242370192893e-05, -4.031225762446411e-05, -4.1293220419902354e-05, -3.904596815118566e-05, -3.39759535563644e-05, -2.686060543055646e-05, -1.873719520517625e-05, -1.0757448762888089e-05, -4.029315277875867e-06, 5.32497097083251e-07, 2.3269969915418187e-06, 1.142639348472585e-06, -2.821178441081429e-06, -8.988768968265504e-06, -1.6493220755364746e-05, -2.4299397409777157e-05, -3.1347495678346604e-05, -3.6697259929496795e-05, -3.965330688515678e-05, -3.985490548075177e-05, -3.731863762368448e-05, -3.2429110433440655e-05, -2.5879908207571134e-05, -1.857375718827825e-05, -1.1496203114802483e-05, -5.580473043664824e-06, -1.5820077123862575e-06, 2.048094138729084e-08, -9.154786084764055e-07, -4.183366854704218e-06, -9.26250413613161e-06, -1.539482400403358e-05, -2.1692350856028497e-05, -2.7260211936663836e-05, -3.1318162655225024e-05, -3.330421168357134e-05, -3.294657653896138e-05, -3.0294871976366267e-05, -2.5707091481308453e-05, -1.9795035768765956e-05, -1.333635373157449e-05, -7.1659210334473755e-06, -2.061580062218127e-06, 1.3600700867755222e-06, 2.723908437474165e-06, 1.942161588885938e-06, -7.796298291395942e-07, -4.976544914825354e-06, -9.992697414418217e-06, -1.507414344814606e-05, -1.947317832673434e-05, -2.2549627828993835e-05, -2.3855469407862984e-05, -2.3191614673123695e-05, -2.062978091998957e-05, -1.6497146134497598e-05, -1.1326717867632397e-05, -5.780804713140242e-06, -5.585849862654868e-07, 3.699358558151289e-06, 6.496542027889518e-06, 7.544707386841765e-06, 6.7983487497258466e-06, 4.455578618944855e-06, 9.259395596927789e-07, -3.22974483424332e-06, -7.378728241747012e-06, -1.0903715519816615e-05, -1.3286223293107469e-05, -1.4174715033732355e-05, -1.3428580132313073e-05, -1.1132555300719105e-05, -7.580255896755261e-06, -3.22975779454282e-06, 1.3621241805594764e-06, 5.617472197627649e-06, 9.016011063067708e-06, 1.116425028158119e-05, 1.1845873814309016e-05, 1.1046952749893535e-05, 8.953147698775865e-06, 5.919910108787008e-06, 2.420368446109933e-06, -1.0215422889814363e-06, -3.903266588167753e-06, -5.811231858388055e-06, -6.474792826338671e-06, -5.799525752081536e-06, -3.875845322909299e-06, -9.623440746509004e-07, 2.5532567633490544e-06, 6.209737421158934e-06, 9.53663038671948e-06, 1.2118171980546322e-05, 1.3648288586409763e-05, 1.3969362044008449e-05, 1.3089927051623818e-05, 1.117941974371206e-05, 8.541217539459467e-06, 5.568226697505452e-06, 2.687412688828772e-06, 3.011328999491525e-07, -1.2667322835113737e-06, -1.8126370378013235e-06, -1.2778484688169556e-06, 2.473326503604767e-07, 2.5396650471520843e-06, 5.276668161968701e-06, 8.08290315035265e-06, 1.0582230061118025e-05, 1.2448790585040115e-05, 1.3449838661472313e-05, 1.3474806110025384e-05, 1.2547038750199135e-05, 1.0817079783009831e-05, 8.538853762729559e-06, 6.032523288013181e-06, 3.639336227934109e-06, 1.674873828960699e-06, 3.870444515996496e-07, -7.558024606169056e-08, 3.189138624293264e-07, 1.4847626061964547e-06, 3.23348717756744e-06, 5.302361842041137e-06, 7.392143288598163e-06, 9.20867569220718e-06, 1.0502609256946016e-05, 1.1101912605226971e-05, 1.0932935765595175e-05, 1.0027542884927243e-05, 8.515706213074736e-06, 6.6050301938958e-06, 4.5503520595957525e-06, 2.617838390506222e-06, 1.048632384481607e-06, 2.6992186263896656e-08, -3.4288763117729104e-07, -4.848425305681303e-08, 8.322361395585176e-07, 2.1442381239467068e-06, 3.6788710531254765e-06, 5.203857654123567e-06, 6.495540219475515e-06, 7.368924798356602e-06, 7.701517461100593e-06, 7.447913503710879e-06, 6.643441793130478e-06, 5.396741471486166e-06, 3.8726361708540935e-06, 2.2679435005557025e-06, 7.837588213988056e-07, -4.019082666673057e-07, -1.1574354630283779e-06, -1.413793143001385e-06, -1.1716946346496115e-06, -4.990267257198866e-07, 4.807484970115183e-07, 1.6073286133178044e-06, 2.7066423626820324e-06, 3.6149572224530857e-06, 4.200715466140537e-06, 4.381189683044795e-06, 4.131898549530888e-06, 3.487747108010808e-06, 2.5360584459122038e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu_1</value></param>
<param><key>value</key><value>0.15e-2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_center</value></param>
<param><key>value</key><value>channel_width/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>w_channel_width</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 2000, 500, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>3.4e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_1_7</value></param>
<param><key>value</key><value>[2.622382453409955e-06, 2.0068987396371085e-06, 1.333393925051496e-06, 6.640565288762446e-07, 6.325814183583134e-08, -4.074368575857079e-07, -6.942357799744059e-07, -7.556611762993271e-07, -5.663034130520828e-07, -1.194551799699184e-07, 5.716180453418929e-07, 1.4739226799065364e-06, 2.536532065278152e-06, 3.6938463381375186e-06, 4.870114480581833e-06, 5.98491214987007e-06, 6.959172424103599e-06, 7.721328984189313e-06, 8.21308458398562e-06, 8.394348697038367e-06, 8.246925062849186e-06, 7.776633538014721e-06, 7.0136188696778845e-06, 6.01080273554544e-06, 4.84049814986065e-06, 3.589418611227302e-06, 2.352405545025249e-06, 1.2253200338818715e-06, 2.976310611302324e-07, -3.547388871538715e-07, -6.757429673598381e-07, -6.341982157209713e-07, -2.2700196211644652e-07, 5.197276777835214e-07, 1.551741092953307e-06, 2.789958898574696e-06, 4.1358016460435465e-06, 5.478191269503441e-06, 6.7017367655353155e-06, 7.695504791627172e-06, 8.36170875118114e-06, 8.62365686771227e-06, 8.432297363469843e-06, 7.770840056764428e-06, 6.657021003775299e-06, 5.142777808941901e-06, 3.3112808068835875e-06, 1.2714757531284704e-06, -8.495126166963018e-07, -2.915590812335722e-06, -4.7918524614942726e-06, -6.3549282458552625e-06, -7.502730113628786e-06, -8.162829544744454e-06, -8.298771717818454e-06, -7.913810804893728e-06, -7.051662578305695e-06, -5.794186108687427e-06, -4.25605367126991e-06, -2.5767512852326035e-06, -9.104568903239851e-07, 5.854863616150396e-07, 1.762649276315642e-06, 2.493231022526743e-06, 2.6805023480847012e-06, 2.267136324007879e-06, 1.2407316489770892e-06, -3.639673877842142e-07, -2.466412524881889e-06, -4.945143246004591e-06, -7.645944606338162e-06, -1.0392719559604302e-05, -1.3000330909562763e-05, -1.5288447684724815e-05, -1.7095377188525163e-05, -1.829082248150371e-05, -1.8786538930726238e-05, -1.8544056729297154e-05, -1.757875179464463e-05, -1.5959922166075557e-05, -1.38067189254798e-05, -1.128017083829036e-05, -8.5718083937536e-06, -5.8896825976262335e-06, -3.442784645812935e-06, -1.425026880497171e-06, 8.215078337615332e-20, 7.123069849512831e-07, 6.457555059569131e-07, -2.0557799018661171e-07, -1.7855024907476036e-06, -3.978527729486814e-06, -6.617289272980997e-06, -9.494119694863912e-06, -1.237597916770028e-05, -1.5021676517790183e-05, -1.720011823636014e-05, -1.8708204152062535e-05, -1.9387009160709567e-05, -1.913494816108141e-05, -1.7916880096890964e-05, -1.576832619321067e-05, -1.2794411304639652e-05, -9.163457434624434e-06, -5.095614142192062e-06, -8.47292596972693e-07, 3.307513679828844e-06, 7.097652542142896e-06, 1.0275458407704718e-05, 1.2636052815651055e-05, 1.4033787010703236e-05, 1.439450807083631e-05, 1.3722634321311489e-05, 1.2102372238587122e-05, 9.692865205579437e-06, 6.717510132148163e-06, 3.448134521022439e-06, 1.8514899124966178e-07, -2.764920964182238e-06, -5.112840426590992e-06, -6.609247520827921e-06, -7.064671535772504e-06, -6.365404260577634e-06, -4.483922566578258e-06, -1.4829527117399266e-06, 2.48725586970977e-06, 7.198394541774178e-06, 1.2359699212538544e-05, 1.7638651115703396e-05, 2.2685258954879828e-05, 2.715819573495537e-05, 3.075079439440742e-05, 3.321492476970889e-05, 3.438090061536059e-05, 3.4171829611295834e-05, 3.2611129427095875e-05, 2.982261503348127e-05, 2.60229116975097e-05, 2.1506642951862887e-05, 1.6625428543193266e-05, 1.1762086614908185e-05, 7.301986443053465e-06, 3.603656296036206e-06, 9.708536481412011e-07, -3.7171261624280305e-07, -2.9710781745961867e-07, 1.212198981193069e-06, 4.060822448082035e-06, 8.045493814279325e-06, 1.2868410522060003e-05, 1.81580562639283e-05, 2.3496044377679937e-05, 2.844804839696735e-05, 3.2596544770058244e-05, 3.557290619937703e-05, 3.708642179844901e-05, 3.6947876651538536e-05, 3.508594454615377e-05, 3.155487866024487e-05, 2.653278897923883e-05, 2.0310537365730852e-05, 1.3271796888147946e-05, 5.865727871423587e-06, -1.4258359897212358e-06, -8.124261512421072e-06, -1.3790404409519397e-05, -1.805854481062852e-05, -2.0665334886871278e-05, -2.147148370568175e-05, -2.047438101726584e-05, -1.781055107130669e-05, -1.3747543562203646e-05, -8.665725545142777e-06, -3.0311339287436567e-06, 2.6386685476609273e-06, 7.813269803591538e-06, 1.1989768609055318e-05, 1.4731761439179536e-05, 1.570396671013441e-05, 1.4699785424454603e-05, 1.1659562005661428e-05, 6.6780053202819545e-06, -4.971666966643111e-20, -7.995062333066016e-06, -1.681944922893308e-05, -2.591194788692519e-05, -3.467890928732231e-05, -4.253848237567581e-05, -4.896469181403518e-05, -5.3528070566244423e-05, -5.592962770606391e-05, -5.602551391348243e-05, -5.384029645938426e-05, -4.9567690439289436e-05, -4.355849523562938e-05, -3.62963110092096e-05, -2.8362848752294667e-05, -2.0395171304699033e-05, -1.3038024917477742e-05, -6.8948133957746904e-06, -2.480883495081798e-06, -1.8274870683399058e-07, -2.264248024630433e-07, -2.6574471121421084e-06, -7.334280326176668e-06, -1.3935844435764011e-05, -2.1982814359944314e-05, -3.087131699430756e-05, -3.9916652895044535e-05, -4.8403879191027954e-05, -5.5641590734012425e-05, -6.101471808506176e-05, -6.403253064490855e-05, -6.436786497943103e-05, -6.188475526869297e-05, -5.665184653480537e-05, -4.894063749816269e-05, -3.9208243833854795e-05, -2.806587508530356e-05, -1.623506614123471e-05, -4.494898803386604e-06, 6.37597986496985e-06, 1.5658211850677617e-05, 2.2747004550183192e-05, 2.7199545002076775e-05, 2.8770880817319266e-05, 2.7435326046543196e-05, 2.3391512513626367e-05, 1.7050531823770143e-05, 9.007720109366346e-06, -5.063597428853296e-20, -9.148187018581666e-06, -1.758645157678984e-05, -2.4502976884832606e-05, -2.918712198152207e-05, -3.108531382167712e-05, -2.984591446875129e-05, -2.5349487259518355e-05, -1.7721862604958005e-05, -7.328868832701119e-06, 5.247271019470645e-06, 1.9248280295869336e-05, 3.3794156479416415e-05, 4.794755659531802e-05, 6.078349906601943e-05, 7.14592169970274e-05, 7.927881233626977e-05, 8.374772005481645e-05, 8.461284596705809e-05, 8.188482752302662e-05, 7.584079867228866e-05, 6.70069275656715e-05, 5.612176755676046e-05, 4.408307358971797e-05, 3.188167465850711e-05, 2.0527410015347414e-05, 1.0972444215440191e-05, 4.037917278765235e-06, 3.4943451510116574e-07, 2.8644902272390027e-07, 3.949597612518119e-06, 1.11487124740961e-05, 2.1412737623904832e-05, 3.402110087336041e-05, 4.805449862033129e-05, 6.246151315281168e-05, 7.613624620717019e-05, 8.80012012203224e-05, 9.708934521768242e-05, 0.00010261887655360624, 0.00010405515786260366, 0.00010115483746631071, 9.398848487762734e-05, 8.293991413665935e-05, 6.868159107398242e-05, 5.212807809584774e-05, 3.4370332286925986e-05, 1.6595782653894275e-05, -3.86560602948301e-19, -1.4303484022093471e-05, -2.536837746447418e-05, -3.248933353461325e-05, -3.525840293150395e-05, -3.359971378813498e-05, -2.7779446099884808e-05, -1.8390001059742644e-05, -6.309201580734225e-06, 7.362746146100108e-06, 2.138402487616986e-05, 3.446387199801393e-05, 4.536025880952366e-05, 5.2975257858633995e-05, 5.6440840126015246e-05, 5.518843681784347e-05, 4.8996804252965376e-05, 3.801426646532491e-05, 2.2753249140805565e-05, 4.057182195538189e-06, -1.6958128981059417e-05, -3.8984533603070304e-05, -6.06172761763446e-05, -8.04592709755525e-05, -9.722632239572704e-05, -0.00010984512482536957, -0.00011753669241443276, -0.0001198785612359643, -0.00011684091441566125, -0.00010879342153202742, -9.648183186072856e-05, -8.097604586509988e-05, -6.359260441968217e-05, -4.579779124469496e-05, -2.9097900551278144e-05, -1.492517640144797e-05, -4.527756118477555e-06, 1.1278054898866685e-06, 1.433989268662117e-06, -3.806434506259393e-06, -1.4359578017320018e-05, -2.957200922537595e-05, -4.8414287448395044e-05, -6.955358549021184e-05, -9.1450237960089e-05, -0.00011247133807046339, -0.00013101288641337305, -0.00014562129217665642, -0.00015510529919993132, -0.00015862945292610675, -0.00015578184684272856, -0.00014661080786027014, -0.00013162723917048424, -0.00011177201668033376, -8.835042535793036e-05, -6.293825572356582e-05, -3.7266232538968325e-05, -1.3091317669022828e-05, 7.935660505609121e-06, 2.4395909349550493e-05, 3.521261169225909e-05, 3.973634011344984e-05, 3.779915641644038e-05, 2.9732904295087792e-05, 1.6349844372598454e-05, -1.1133173529742635e-06, -2.1084328182041645e-05, -4.177083246759139e-05, -6.12939620623365e-05, -7.783022010698915e-05, -8.975099626695737e-05, -9.574909199727699e-05, -9.494254481978714e-05, -8.694765710970387e-05, -7.19151648809202e-05, -5.0526530685601756e-05, -2.3949956812430173e-05, 6.240906714083394e-06, 3.817994365817867e-05, 6.984508945606649e-05, 9.920832962961867e-05, 0.000124387996038422, 0.00014379181084223092, 0.00015623995568603277, 0.0001610582257853821, 0.0001581342949066311, 0.00014793191803619266, 0.00013146201672498137, 0.00011021178215742111, 8.603695459896699e-05, 6.102500992710702e-05, 3.733905396074988e-05, 1.7054169802577235e-05, 1.9984447590104537e-06, -6.38918436379754e-06, -7.17336661182344e-06, 4.759688234497502e-19, 1.4869176084175706e-05, 3.6568206269294024e-05, 6.36844415566884e-05, 9.435815445613116e-05, 0.00012641726061701775, 0.0001575372734805569, 0.00018541482859291136, 0.00020794167357962579, 0.00022336610709317029, 0.00023042940301820636, 0.00022846661158837378, 0.00021746366110164672, 0.0001980662054847926, 0.00017153826775029302, 0.00013967427366878837, 0.00010466953972354531, 6.895912520121783e-05, 3.503678090055473e-05, 5.267310370982159e-06, -1.8293419998371974e-05, -3.405714960535988e-05, -4.102833918295801e-05, -3.888579158228822e-05, -2.801425762299914e-05, -9.482860150455963e-06, 1.5028518646431621e-05, 4.3349951738491654e-05, 7.298075070139021e-05, 0.0001012755892588757, 0.00012564392818603665, 0.00014374747115653008, 0.00015368104504887015, 0.00015412276843562722, 0.0001444419613108039, 0.0001247559703188017, 9.593122376827523e-05, 5.9527639677980915e-05, 1.7689993910607882e-05, -2.700613549677655e-05, -7.17427465133369e-05, -0.00011366826220182702, -0.0001501112274127081, -0.00017878285143524408, -0.00019795291882473975, -0.0002065853914245963, -0.00020442312234081328, -0.0001920145732583478, -0.00017067995213437825, -0.000142418677569367, -0.00010976435441989452, -7.559780351584777e-05, -4.2931798816425726e-05, -1.4683294466522057e-05, 6.549456429638667e-06, 1.8688288037083112e-05, 2.0339328330010176e-05, 1.0907290743489284e-05, -9.349378160550259e-06, -3.932734398404136e-05, -7.715124229434878e-05, -0.0001203057836391963, -0.0001658177498029545, -0.00021047471091151237, -0.0002510643098503351, -0.00028461628244258463, -0.0003086288343183696, -0.0003212622832506895, -0.00032148498576134443, -0.0003091593680437654, -0.00028506203670985997, -0.0002508348261471838, -0.00020886980928480625, -0.00016213661001529545, -0.00011396440822863951, -6.779417890356854e-05, -2.6920066375168972e-05, 5.760933618148556e-06, 2.7971873350907117e-05, 3.82342332159169e-05, 3.5987799492431805e-05, 2.164230500056874e-05, -3.4437225622241385e-06, -3.705619747051969e-05, -7.62844574637711e-05, -0.00011773466394515708, -0.00015778219676576555, -0.00019284414884168655, -0.0002196518616983667, -0.0002355025935685262, -0.00023847116972319782, -0.00022756530961487442, -0.00020281216711737216, -0.00016526876424904913, -0.00011695479770423844, -6.071198367862962e-05, -2.7772325402647653e-19, 6.13565935054794e-05, 0.00011945151345571503, 0.00017058908997569233, 0.0002115638490067795, 0.00023990565387066454, 0.00025407233624719083, 0.0002535738458391279, 0.00023901823442429304, 0.0002120753051713109, 0.00017535951337777078, 0.0001322402385994792, 8.659312879899517e-05, 4.251053906045854e-05, 3.992569418187486e-06, -2.535810199333355e-05, -4.261452704668045e-05, -4.575560524244793e-05, -3.383009971003048e-05, -7.041494427539874e-06, 3.325360012240708e-05, 8.463420817861333e-05, 0.000143785189720802, 0.0002067368186544627, 0.0002691563859116286, 0.00032667029881849885, 0.00037519275792874396, 0.00041123604751192033, 0.0004321791639085859, 0.00043647337588481605, 0.000423769757617265, 0.00039495647069998085, 0.0003521041653584689, 0.0002983206941280514, 0.0002375266922172159, 0.00017416727496311069, 0.0001128813746618107, 5.815325494040735e-05, 1.3972140550322365e-05, -1.6473983123432845e-05, -3.104707138845697e-05, -2.8830803785240278e-05, -1.0211662811343558e-05, 2.3137663447414525e-05, 6.837237015133724e-05, 0.00012167946988483891, 0.0001785569911589846, 0.00023414820316247642, 0.00028360620490275323, 0.000322461302857846, 0.0003469642251729965, 0.00035437781480140984, 0.0003431958903092891, 0.00031327109900303185, 0.00026584166334941983, 0.00020345367374829948, 0.00012978422455489635, 4.937703852192499e-05, -3.268964428571053e-05, -0.00011117885151179507, -0.00018108633230440319, -0.00023801835777703673, -0.00027852688799612224, -0.00030037687974981964, -0.0003027241909876466, -0.00028619071235880256, -0.00025282881688326597, -0.0002059781108982861, -0.00015002272266428918, -9.006814798340201e-05, -3.1559786293655634e-05, 2.0127688912907615e-05, 6.009963544784114e-05, 8.431856986135244e-05, 8.992021321319044e-05, 7.544393884018064e-05, 4.095953772775829e-05, -1.1920506949536502e-05, -8.014516060939059e-05, -0.00015943868493195623, -0.0002446091384626925, -0.00032992937485687435, -0.000409561675041914, -0.000477995810797438, -0.0005304660880938172, -0.0005633165710605681, -0.0005742861540056765, -0.0005626911879517138, -0.0005294909351505339, -0.00047722976887598634, -0.0004098587960470468, -0.00033245052327401936, -0.0002508255129214376, -0.00017111931811086833, -9.932186367223039e-05, -4.0823055314831436e-05, 4.064368741885494e-19, 2.0123445210629143e-05, 1.8117911167792045e-05, -5.728490577894263e-06, -4.9415833927923813e-05, -0.00010936755279544741, -0.00018068608187604696, -0.00025751092471182346, -0.000333453033817932, -0.0004020732012577355, -0.0004573693440761417, -0.0004942353698424995, -0.000508856785017997, -0.000499012996442616, -0.0004642622370738536, -0.0004059937782585621, -0.0003273431211709976, -0.00023297398001886904, -0.00012874361709691584, -2.127450170519296e-05, 8.253537089331076e-05, 0.00017602772277314216, 0.00025328577612526715, 0.0003095846332143992, 0.00034175600740127265, 0.00034843856701627374, 0.00033019448164850473, 0.0002894811623264104, 0.00023048033472150564, 0.00015879474813118577, 8.103494474198669e-05, 4.325972895458108e-06, -6.422933074645698e-05, -0.00011809048010036349, -0.00015178199100773782, -0.00016132043674588203, -0.00014453264884650707, -0.00010124038817593828, -3.329598985146731e-05, 5.553503433475271e-05, 0.00015983691264409572, 0.00027293365565128624, 0.0003873779496643692, 0.0004955028998665512, 0.0005899956449866295, 0.000664449529722333, 0.0007138532819226384, 0.0007349794614128768, 0.0007266419124789536, 0.00068980164360255, 0.0006275122868828475, 0.0005447060102596879, 0.00044783749035559595, 0.0003444083849899471, 0.00024240957282017916, 0.0001497208868386224, 7.351431850111112e-05, 1.9705195882124826e-05, -7.5066095632791985e-06, -5.969956418994116e-06, 2.423608566459734e-05, 8.078764949459583e-05, 0.00015927103231661022, 0.0002534970117267221, 0.00035595224471762776, 0.00045835517812520266, 0.0005522748688235879, 0.0006297673680819571, 0.0006839811103418469, 0.0007096855551935732, 0.0007036829483695328, 0.0006650699069723487, 0.0005953291547484696, 0.0004982416867278516, 0.0003796251257881522, 0.0002469161117915064, 0.00010862691851798445, -2.6283949409844354e-05, -0.00014908025332260877, -0.00025190567248500884, -0.000328380789142102, -0.0003740942047443241, -0.0003869487263727933, -0.00036733667366206646, -0.0003181281790602952, -0.0002444727288093418, -0.00015342628466896713, -5.343164229998365e-05, 4.631117917597294e-05, 0.00013653698260895908, 0.0002086188760586083, 0.00025522991199977696, 0.0002709125983528793, 0.00025251219631172717, 0.0001994407211896032, 0.00011374888708814979, -2.582592082444939e-18, -0.00013504714297596365, -0.0002829238655976951, -0.00043407068005762994, -0.0005785445682704449, -0.000706760969478637, -0.0008102164138108492, -0.000882135471329093, -0.0009179930784739554, -0.0009158727480098605, -0.0008766305400058627, -0.0008038514642976224, -0.000703600060660392, -0.0005839817458763719, -0.0004545464471448213, -0.000325578119372949, -0.00020732272241730243, -0.00010921256034635007, -3.914525223081e-05, -2.8724823550874135e-06, -3.5453977034194395e-06, -4.145253842580132e-05, -0.00011397171329008415, -0.00021574132551904768, -0.00033904032898135483, -0.0004743497120216489, -0.0006110551184974611, -0.000738238450139761, -0.0008454996859654784, -0.0009237474878318608, -0.0009658979251980782, -0.0009674285538494587, -0.0009267440182156861, -0.0008453248883597553, -0.0007276453543454409, -0.0005808650166727602, -0.00041431537829339504, -0.0002388186112511903, -6.588744872715324e-05, 9.31333561311476e-05, 0.0002279202890349552, 0.00032995472429320216, 0.00039317685877904296, 0.00041445993701927364, 0.0003938667068723589, 0.000334667885908857, 0.00024311791639775038, 0.00012800410331692547, -3.585707497240672e-19, -0.00012912903912365437, -0.0002474099164828658, -0.0003435692342463881, -0.0004078962665516883, -0.00043299535172991455, -0.00041437073377892375, -0.0003507970250211656, -0.00024444726295769215, -0.00010076465696329251, 7.191288750618696e-05, 0.0002629501686897129, 0.000460190640296787, 0.0006508539663627744, 0.0008224890916608274, 0.000963909609708935, 0.0010660437401384115, 0.0011226311326026917, 0.0011307138483971357, 0.0010908835101872683, 0.0010072625009343028, 0.0008872179896570742, 0.0007408307865262032, 0.0005801531951874495, 0.0004183128767181188, 0.00026852800510823727, 0.00014310679398477077, 5.250755566521548e-05, 4.530474598141154e-06, 3.702923322634888e-06, 5.09067831444554e-05, 0.000143277837196365, 0.0002743872464634478, 0.00043469376396387815, 0.0006122353370301425, 0.0007935093017295003, 0.0009644774254411459, 0.0011116195237264037, 0.0012229590211063623, 0.0012889798963442445, 0.001303367898799479, 0.0012635146267712116, 0.0011707505909726024, 0.0010302795562893152, 0.000850823475047946, 0.0006439975113607943, 0.00042346285772509873, 0.00020391734142322093, 8.831717444337061e-19, -0.00017480948008596897, -0.00030921297729946673, -0.00039496031240560114, -0.0004274924867786467, -0.00040631258161738515, -0.0003350524348206818, -0.0002212285326095298, -7.570237357867882e-05, 8.811630686977878e-05, 0.00025526591343805194, 0.00041035524918697774, 0.0005387280252762139, 0.0006275824271142483, 0.0006669608410447836, 0.0006505335331894457, 0.0005761156789958477, 0.0004458762414287776, 0.00026622108998708427, 4.7354409616673365e-05, -0.00019744950986932963, -0.00045281247003003955, -0.0007023857324384153, -0.0009300668025389314, -0.0011212077224627137, -0.0012637254549190402, -0.0013490266865119338, -0.001372679602354765, -0.001334776752628386, -0.001239960198290646, -0.0010971034644171596, -0.000918672711122781, -0.0007198111852630973, -0.0005172131932340562, -0.00032787275267764926, -0.0001677981053944677, -5.079020047560334e-05, 1.2623094335140195e-05, 1.6014655557228252e-05, -4.241657006787136e-05, -0.0001596649963175878, -0.00032809912227094173, -0.0005359933129511774, -0.0007683733128942549, -0.0010081147775053978, -0.001237213728018105, -0.0014381357468664646, -0.0015951412497088313, -0.0016954878810793161, -0.0017304178327322006, -0.0016958540072664618, -0.001592749380506575, -0.0014270605752244592, -0.001209345064125955, -0.0009540071478113532, -0.0006782486452721059, -0.0004007987445220351, -0.0001405193324899301, 8.501256525050849e-05, 0.000260837230598554, 0.0003757584490813315, 0.00042321564978919923, 0.0004018136241938919, 0.00031546695390716195, 0.00017314482829533517, -1.1767918294935953e-05, -0.00022244901629164815, -0.00043988513061776757, -0.0006442948943004012, -0.0008166226325556636, -0.0009399917908012867, -0.001001005177386105, -0.0009907972998917103, -0.0009057524148374796, -0.0007478339830413461, -0.0005244966014288366, -0.0002481828269083053, 6.45600666757673e-05, 0.00039428132004104555, 0.0007200569962151349, 0.0010210443288087845, 0.001278043957427144, 0.0014749517431482673, 0.0015999908791854978, 0.001646628137677908, 0.0016141030937433243, 0.0015075273113325238, 0.0013375411508604884, 0.0011195510160177946, 0.0008726002997718751, 0.0006179568590596318, 0.0003775192308239639, 0.0001721620064927265, 2.014351775869727e-05, -6.43029052298516e-05, -7.208679744508117e-05, 2.6941533112745066e-18, 0.00014898112567607313, 0.00036585761699825525, 0.0006362261483445764, 0.0009413105435669422, 0.0012593334540724754, 0.001567126833833754, 0.0018418632680550218, 0.0020627763587981462, 0.0022127442061901093, 0.0022796117700636387, 0.002257149899378419, 0.002145579783245921, 0.0019516156753525138, 0.0016880163457244635, 0.0013726806500926614, 0.001027345540933311, 0.0006759846583008766, 0.0003430235665291548, 5.1504961447790265e-05, -0.00017865751578938216, -0.0003322054399177432, -0.0003997239109594375, -0.00037839970900677145, -0.0002722879871726036, -9.206277900375426e-05, 0.00014573441876564175, 0.00041989603778347373, 0.0007061135256662965, 0.0009787911549210548, 0.0012129745446145535, 0.001386249321512878, 0.0014804658712819219, 0.0014831596054136753, 0.0013885560911148787, 0.0011980816489085555, 0.0009203355293720961, 0.0005705216317437589, 0.00016937701730057597, -0.00025832635583356023, -0.0006855986430309713, -0.0010852329432964325, -0.001431841286830604, -0.0017037733923643827, -0.0018847702303901315, -0.0019652280025184155, -0.0019429716048762202, -0.0018234759336337447, -0.0016195118660107255, -0.001350239384919405, -0.0010398091981187463, -0.0007155772764235735, -0.0004060578066855669, -0.00013877150195185095, 6.185238453326747e-05, 0.0001763606705935672, 0.0001918034249683842, 0.00010278524860041216, -8.804354001767933e-05, -0.00037009804509580135, -0.0007255699019879103, -0.0011306904489174485, -0.0015574562130495906, -0.001975691644474864, -0.002355295931920409, -0.0026685064658522606, -0.0028920115437358618, -0.003008743282407522, -0.0030092266388237476, -0.0028923603240400553, -0.00266558350995183, -0.002344394102692604, -0.0019512613071128726, -0.001513996976427734, -0.0010637129889801145, -0.0006325081922113895, -0.0002510589256417006, 5.370632788981311e-05, 0.00026067206636071205, 0.00035618292167782784, 0.00033514376264065504, 0.00020148465409874916, -3.205064422218129e-05, -0.0003447840572334826, -0.0007095901528373361, -0.0010948857525363564, -0.0014669756637886167, -0.001792584778741002, -0.002041381783783436, -0.0021883100271224976, -0.0022155456244945526, -0.002113929484039545, -0.001883762190118432, -0.0015348942251875997, -0.0010860988404601812, -0.0005637642461806536, -3.968857246782505e-18, 0.0005697082378901541, 0.0011091220658272505, 0.001583958393894136, 0.0019644773565232754, 0.002227756194770336, 0.0023594715166836977, 0.0023550516925752163, 0.0022201091051101685, 0.0019701048731803894, 0.0016292707296088338, 0.0012288561556488276, 0.0008048282470554113, 0.0003951916005462408, 3.7124780646990985e-05, -0.00023585089365951717, -0.00039645779179409146, -0.00042580548324622214, -0.00031492504058405757, -6.557149026775733e-05, 0.0003097737208008766, 0.000788709323387593, 0.0013404787750914693, 0.0019281817367300391, 0.0025114750023931265, 0.0030495633836835623, 0.0035042590461671352, 0.0038428776897490025, 0.00404075812548399, 0.004083199426531792, 0.003966675605624914, 0.003699220484122634, 0.003299945266917348, 0.002797718159854412, 0.002229094970971346, 0.0016356443520635366, 0.0010608683805912733, 0.0005469415918923914, 0.00013151293387636542, -0.0001551864406792447, -0.0002927093009930104, -0.0002720473275985569, -9.644226520322263e-05, 0.00021871825447306037, 0.0006469225627370179, 0.0011524091241881251, 0.001692760968580842, 0.0022220350801944733, 0.002694194670766592, 0.0030665933154523373, 0.0033032442443072796, 0.0033776313066482544, 0.0032748389057815075, 0.002992835594341159, 0.0025428037624806166, 0.0019484779331833124, 0.0012445285683497787, 0.0004741043958347291, -0.00031429564114660025, -0.0010703919688239694, -0.0017458717338740826, -0.002298035193234682, -0.0026930635794997215, -0.0029086607974022627, -0.0029358570463955402, -0.002779832109808922, -0.0024596841540187597, -0.002007140778005123, -0.0014643085887655616, -0.0008806033292785287, -0.000309094728436321, 0.0001974763727048412, 0.0005907068261876702, 0.0008302669739350677, 0.0008870781166478992, 0.0007456839084625244, 0.00040562747744843364, -0.00011828373681055382, -0.0007968601421453059, -0.0015885084867477417, -0.0024421727284789085, -0.003301029559224844, -0.004106669686734676, -0.004803457763046026, -0.005342745687812567, -0.005686620250344276, -0.005810894072055817, -0.0057071056216955185, -0.005383368115872145, -0.004863976966589689, -0.004187797661870718, -0.0034055334981530905, -0.0025760598946362734, -0.0017620950238779187, -0.0010255126981064677, -0.00042265685624442995, 4.571349135186528e-18, 0.00020951696205884218, 0.00018917935085482895, -5.9989608416799456e-05, -0.000519031600560993, -0.0011522057466208935, -0.0019094246672466397, -0.002729809610173106, -0.003546118503436446, -0.004289719276130199, -0.004895754624158144, -0.005308101419359446, -0.005483756307512522, -0.005396303255110979, -0.005038193892687559, -0.004421640187501907, -0.00357804330997169, -0.002555962186306715, -0.0014177642296999693, -0.00023517769295722246, 0.0009159311302937567, 0.001961181405931711, 0.0028332823421806097, 0.003477200400084257, 0.0038544919807463884, 0.003946460783481598, 0.0037558842450380325, 0.0033071544021368027, 0.0026447903364896774, 0.0018304110271856189, 0.0009383663418702781, 5.032741682953201e-05, -0.000750772887840867, -0.0013870070688426495, -0.0017914619529619813, -0.0019135319162160158, -0.0017230879748240113, -0.0012131859548389912, -0.00040108372922986746, 0.0006725398125126958, 0.001946143340319395, 0.003341499250382185, 0.00476920697838068, 0.00613515917211771, 0.007347488310188055, 0.008323491550981998, 0.008996007032692432, 0.009318758733570576, 0.009270239621400833, 0.008855828084051609, 0.00810791365802288, 0.007084018085151911, 0.005862978287041187, 0.004539444111287594, 0.0032170796766877174, 0.0020009237341582775, 0.000989487860351801, 0.00026715616695582867, -0.00010252530773868784, -8.215222624130547e-05, 0.00033607103978283703, 0.0011290027759969234, 0.00224352371878922, 0.003599768504500389, 0.005096440203487873, 0.006617865990847349, 0.008042309433221817, 0.009250943548977375, 0.010136849246919155, 0.01061334740370512, 0.010621052235364914, 0.01013305876404047, 0.009157859720289707, 0.007739689666777849, 0.005956218112260103, 0.00391367869451642, 0.0017397375777363777, -0.00042544235475361347, -0.0024393268395215273, -0.00416760565713048, -0.005494488403201103, -0.00633193738758564, -0.006627105176448822, -0.006367393769323826, -0.005582677666097879, -0.0043444386683404446, -0.002761784940958023, -0.0009745490970090032, 0.0008561286958865821, 0.0025591114535927773, 0.003965709824115038, 0.004922383930534124, 0.005302777513861656, 0.0050181858241558075, 0.004025635309517384, 0.0023329041432589293, -5.4940000389082825e-18, -0.002863129833713174, -0.0061026401817798615, -0.009530278854072094, -0.012935775332152843, -0.016101345419883728, -0.0188173558562994, -0.020898066461086273, -0.022196320816874504, -0.02261612005531788, -0.022122055292129517, -0.02074486017227173, -0.018582439050078392, -0.015796195715665817, -0.012602642178535461, -0.0092606907710433, -0.006055331788957119, -0.0032786098308861256, -0.0012091313255950809, -9.139253234025091e-05, -0.00011633031681412831, -0.0014044520212337375, -0.003992782905697823, -0.007826664485037327, -0.012757154181599617, -0.018544435501098633, -0.02486729621887207, -0.031338270753622055, -0.03752380236983299, -0.04296824336051941, -0.04722044989466667, -0.04986129701137543, -0.05053059384226799, -0.04895159602165222, -0.04495156183838844, -0.0384770967066288, -0.029603049159049988, -0.018534336239099503, -0.005600385833531618, 0.008757706731557846, 0.024006666615605354, 0.03954622894525528, 0.05473865196108818, 0.06894094496965408, 0.08153798431158066, 0.091974638402462, 0.09978508949279785, 0.10461755841970444, 0.10625314712524414, 0.10461755841970444, 0.09978508949279785, 0.091974638402462, 0.08153798431158066, 0.06894094496965408, 0.05473865196108818, 0.03954622894525528, 0.024006666615605354, 0.008757706731557846, -0.005600385833531618, -0.018534336239099503, -0.029603049159049988, -0.0384770967066288, -0.04495156183838844, -0.04895159602165222, -0.05053059384226799, -0.04986129701137543, -0.04722044989466667, -0.04296824336051941, -0.03752380236983299, -0.031338270753622055, -0.02486729621887207, -0.018544435501098633, -0.012757154181599617, -0.007826664485037327, -0.003992782905697823, -0.0014044520212337375, -0.00011633031681412831, -9.139253234025091e-05, -0.0012091313255950809, -0.0032786098308861256, -0.006055331788957119, -0.0092606907710433, -0.012602642178535461, -0.015796195715665817, -0.018582439050078392, -0.02074486017227173, -0.022122055292129517, -0.02261612005531788, -0.022196320816874504, -0.020898066461086273, -0.0188173558562994, -0.016101345419883728, -0.012935775332152843, -0.009530278854072094, -0.0061026401817798615, -0.002863129833713174, -5.4940000389082825e-18, 0.0023329041432589293, 0.004025635309517384, 0.0050181858241558075, 0.005302777513861656, 0.004922383930534124, 0.003965709824115038, 0.0025591114535927773, 0.0008561286958865821, -0.0009745490970090032, -0.002761784940958023, -0.0043444386683404446, -0.005582677666097879, -0.006367393769323826, -0.006627105176448822, -0.00633193738758564, -0.005494488403201103, -0.00416760565713048, -0.0024393268395215273, -0.00042544235475361347, 0.0017397375777363777, 0.00391367869451642, 0.005956218112260103, 0.007739689666777849, 0.009157859720289707, 0.01013305876404047, 0.010621052235364914, 0.01061334740370512, 0.010136849246919155, 0.009250943548977375, 0.008042309433221817, 0.006617865990847349, 0.005096440203487873, 0.003599768504500389, 0.00224352371878922, 0.0011290027759969234, 0.00033607103978283703, -8.215222624130547e-05, -0.00010252530773868784, 0.00026715616695582867, 0.000989487860351801, 0.0020009237341582775, 0.0032170796766877174, 0.004539444111287594, 0.005862978287041187, 0.007084018085151911, 0.00810791365802288, 0.008855828084051609, 0.009270239621400833, 0.009318758733570576, 0.008996007032692432, 0.008323491550981998, 0.007347488310188055, 0.00613515917211771, 0.00476920697838068, 0.003341499250382185, 0.001946143340319395, 0.0006725398125126958, -0.00040108372922986746, -0.0012131859548389912, -0.0017230879748240113, -0.0019135319162160158, -0.0017914619529619813, -0.0013870070688426495, -0.000750772887840867, 5.032741682953201e-05, 0.0009383663418702781, 0.0018304110271856189, 0.0026447903364896774, 0.0033071544021368027, 0.0037558842450380325, 0.003946460783481598, 0.0038544919807463884, 0.003477200400084257, 0.0028332823421806097, 0.001961181405931711, 0.0009159311302937567, -0.00023517769295722246, -0.0014177642296999693, -0.002555962186306715, -0.00357804330997169, -0.004421640187501907, -0.005038193892687559, -0.005396303255110979, -0.005483756307512522, -0.005308101419359446, -0.004895754624158144, -0.004289719276130199, -0.003546118503436446, -0.002729809610173106, -0.0019094246672466397, -0.0011522057466208935, -0.000519031600560993, -5.9989608416799456e-05, 0.00018917935085482895, 0.00020951696205884218, 4.571349135186528e-18, -0.00042265685624442995, -0.0010255126981064677, -0.0017620950238779187, -0.0025760598946362734, -0.0034055334981530905, -0.004187797661870718, -0.004863976966589689, -0.005383368115872145, -0.0057071056216955185, -0.005810894072055817, -0.005686620250344276, -0.005342745687812567, -0.004803457763046026, -0.004106669686734676, -0.003301029559224844, -0.0024421727284789085, -0.0015885084867477417, -0.0007968601421453059, -0.00011828373681055382, 0.00040562747744843364, 0.0007456839084625244, 0.0008870781166478992, 0.0008302669739350677, 0.0005907068261876702, 0.0001974763727048412, -0.000309094728436321, -0.0008806033292785287, -0.0014643085887655616, -0.002007140778005123, -0.0024596841540187597, -0.002779832109808922, -0.0029358570463955402, -0.0029086607974022627, -0.0026930635794997215, -0.002298035193234682, -0.0017458717338740826, -0.0010703919688239694, -0.00031429564114660025, 0.0004741043958347291, 0.0012445285683497787, 0.0019484779331833124, 0.0025428037624806166, 0.002992835594341159, 0.0032748389057815075, 0.0033776313066482544, 0.0033032442443072796, 0.0030665933154523373, 0.002694194670766592, 0.0022220350801944733, 0.001692760968580842, 0.0011524091241881251, 0.0006469225627370179, 0.00021871825447306037, -9.644226520322263e-05, -0.0002720473275985569, -0.0002927093009930104, -0.0001551864406792447, 0.00013151293387636542, 0.0005469415918923914, 0.0010608683805912733, 0.0016356443520635366, 0.002229094970971346, 0.002797718159854412, 0.003299945266917348, 0.003699220484122634, 0.003966675605624914, 0.004083199426531792, 0.00404075812548399, 0.0038428776897490025, 0.0035042590461671352, 0.0030495633836835623, 0.0025114750023931265, 0.0019281817367300391, 0.0013404787750914693, 0.000788709323387593, 0.0003097737208008766, -6.557149026775733e-05, -0.00031492504058405757, -0.00042580548324622214, -0.00039645779179409146, -0.00023585089365951717, 3.7124780646990985e-05, 0.0003951916005462408, 0.0008048282470554113, 0.0012288561556488276, 0.0016292707296088338, 0.0019701048731803894, 0.0022201091051101685, 0.0023550516925752163, 0.0023594715166836977, 0.002227756194770336, 0.0019644773565232754, 0.001583958393894136, 0.0011091220658272505, 0.0005697082378901541, -3.968857246782505e-18, -0.0005637642461806536, -0.0010860988404601812, -0.0015348942251875997, -0.001883762190118432, -0.002113929484039545, -0.0022155456244945526, -0.0021883100271224976, -0.002041381783783436, -0.001792584778741002, -0.0014669756637886167, -0.0010948857525363564, -0.0007095901528373361, -0.0003447840572334826, -3.205064422218129e-05, 0.00020148465409874916, 0.00033514376264065504, 0.00035618292167782784, 0.00026067206636071205, 5.370632788981311e-05, -0.0002510589256417006, -0.0006325081922113895, -0.0010637129889801145, -0.001513996976427734, -0.0019512613071128726, -0.002344394102692604, -0.00266558350995183, -0.0028923603240400553, -0.0030092266388237476, -0.003008743282407522, -0.0028920115437358618, -0.0026685064658522606, -0.002355295931920409, -0.001975691644474864, -0.0015574562130495906, -0.0011306904489174485, -0.0007255699019879103, -0.00037009804509580135, -8.804354001767933e-05, 0.00010278524860041216, 0.0001918034249683842, 0.0001763606705935672, 6.185238453326747e-05, -0.00013877150195185095, -0.0004060578066855669, -0.0007155772764235735, -0.0010398091981187463, -0.001350239384919405, -0.0016195118660107255, -0.0018234759336337447, -0.0019429716048762202, -0.0019652280025184155, -0.0018847702303901315, -0.0017037733923643827, -0.001431841286830604, -0.0010852329432964325, -0.0006855986430309713, -0.00025832635583356023, 0.00016937701730057597, 0.0005705216317437589, 0.0009203355293720961, 0.0011980816489085555, 0.0013885560911148787, 0.0014831596054136753, 0.0014804658712819219, 0.001386249321512878, 0.0012129745446145535, 0.0009787911549210548, 0.0007061135256662965, 0.00041989603778347373, 0.00014573441876564175, -9.206277900375426e-05, -0.0002722879871726036, -0.00037839970900677145, -0.0003997239109594375, -0.0003322054399177432, -0.00017865751578938216, 5.1504961447790265e-05, 0.0003430235665291548, 0.0006759846583008766, 0.001027345540933311, 0.0013726806500926614, 0.0016880163457244635, 0.0019516156753525138, 0.002145579783245921, 0.002257149899378419, 0.0022796117700636387, 0.0022127442061901093, 0.0020627763587981462, 0.0018418632680550218, 0.001567126833833754, 0.0012593334540724754, 0.0009413105435669422, 0.0006362261483445764, 0.00036585761699825525, 0.00014898112567607313, 2.6941533112745066e-18, -7.208679744508117e-05, -6.43029052298516e-05, 2.014351775869727e-05, 0.0001721620064927265, 0.0003775192308239639, 0.0006179568590596318, 0.0008726002997718751, 0.0011195510160177946, 0.0013375411508604884, 0.0015075273113325238, 0.0016141030937433243, 0.001646628137677908, 0.0015999908791854978, 0.0014749517431482673, 0.001278043957427144, 0.0010210443288087845, 0.0007200569962151349, 0.00039428132004104555, 6.45600666757673e-05, -0.0002481828269083053, -0.0005244966014288366, -0.0007478339830413461, -0.0009057524148374796, -0.0009907972998917103, -0.001001005177386105, -0.0009399917908012867, -0.0008166226325556636, -0.0006442948943004012, -0.00043988513061776757, -0.00022244901629164815, -1.1767918294935953e-05, 0.00017314482829533517, 0.00031546695390716195, 0.0004018136241938919, 0.00042321564978919923, 0.0003757584490813315, 0.000260837230598554, 8.501256525050849e-05, -0.0001405193324899301, -0.0004007987445220351, -0.0006782486452721059, -0.0009540071478113532, -0.001209345064125955, -0.0014270605752244592, -0.001592749380506575, -0.0016958540072664618, -0.0017304178327322006, -0.0016954878810793161, -0.0015951412497088313, -0.0014381357468664646, -0.001237213728018105, -0.0010081147775053978, -0.0007683733128942549, -0.0005359933129511774, -0.00032809912227094173, -0.0001596649963175878, -4.241657006787136e-05, 1.6014655557228252e-05, 1.2623094335140195e-05, -5.079020047560334e-05, -0.0001677981053944677, -0.00032787275267764926, -0.0005172131932340562, -0.0007198111852630973, -0.000918672711122781, -0.0010971034644171596, -0.001239960198290646, -0.001334776752628386, -0.001372679602354765, -0.0013490266865119338, -0.0012637254549190402, -0.0011212077224627137, -0.0009300668025389314, -0.0007023857324384153, -0.00045281247003003955, -0.00019744950986932963, 4.7354409616673365e-05, 0.00026622108998708427, 0.0004458762414287776, 0.0005761156789958477, 0.0006505335331894457, 0.0006669608410447836, 0.0006275824271142483, 0.0005387280252762139, 0.00041035524918697774, 0.00025526591343805194, 8.811630686977878e-05, -7.570237357867882e-05, -0.0002212285326095298, -0.0003350524348206818, -0.00040631258161738515, -0.0004274924867786467, -0.00039496031240560114, -0.00030921297729946673, -0.00017480948008596897, 8.831717444337061e-19, 0.00020391734142322093, 0.00042346285772509873, 0.0006439975113607943, 0.000850823475047946, 0.0010302795562893152, 0.0011707505909726024, 0.0012635146267712116, 0.001303367898799479, 0.0012889798963442445, 0.0012229590211063623, 0.0011116195237264037, 0.0009644774254411459, 0.0007935093017295003, 0.0006122353370301425, 0.00043469376396387815, 0.0002743872464634478, 0.000143277837196365, 5.09067831444554e-05, 3.702923322634888e-06, 4.530474598141154e-06, 5.250755566521548e-05, 0.00014310679398477077, 0.00026852800510823727, 0.0004183128767181188, 0.0005801531951874495, 0.0007408307865262032, 0.0008872179896570742, 0.0010072625009343028, 0.0010908835101872683, 0.0011307138483971357, 0.0011226311326026917, 0.0010660437401384115, 0.000963909609708935, 0.0008224890916608274, 0.0006508539663627744, 0.000460190640296787, 0.0002629501686897129, 7.191288750618696e-05, -0.00010076465696329251, -0.00024444726295769215, -0.0003507970250211656, -0.00041437073377892375, -0.00043299535172991455, -0.0004078962665516883, -0.0003435692342463881, -0.0002474099164828658, -0.00012912903912365437, -3.585707497240672e-19, 0.00012800410331692547, 0.00024311791639775038, 0.000334667885908857, 0.0003938667068723589, 0.00041445993701927364, 0.00039317685877904296, 0.00032995472429320216, 0.0002279202890349552, 9.31333561311476e-05, -6.588744872715324e-05, -0.0002388186112511903, -0.00041431537829339504, -0.0005808650166727602, -0.0007276453543454409, -0.0008453248883597553, -0.0009267440182156861, -0.0009674285538494587, -0.0009658979251980782, -0.0009237474878318608, -0.0008454996859654784, -0.000738238450139761, -0.0006110551184974611, -0.0004743497120216489, -0.00033904032898135483, -0.00021574132551904768, -0.00011397171329008415, -4.145253842580132e-05, -3.5453977034194395e-06, -2.8724823550874135e-06, -3.914525223081e-05, -0.00010921256034635007, -0.00020732272241730243, -0.000325578119372949, -0.0004545464471448213, -0.0005839817458763719, -0.000703600060660392, -0.0008038514642976224, -0.0008766305400058627, -0.0009158727480098605, -0.0009179930784739554, -0.000882135471329093, -0.0008102164138108492, -0.000706760969478637, -0.0005785445682704449, -0.00043407068005762994, -0.0002829238655976951, -0.00013504714297596365, -2.582592082444939e-18, 0.00011374888708814979, 0.0001994407211896032, 0.00025251219631172717, 0.0002709125983528793, 0.00025522991199977696, 0.0002086188760586083, 0.00013653698260895908, 4.631117917597294e-05, -5.343164229998365e-05, -0.00015342628466896713, -0.0002444727288093418, -0.0003181281790602952, -0.00036733667366206646, -0.0003869487263727933, -0.0003740942047443241, -0.000328380789142102, -0.00025190567248500884, -0.00014908025332260877, -2.6283949409844354e-05, 0.00010862691851798445, 0.0002469161117915064, 0.0003796251257881522, 0.0004982416867278516, 0.0005953291547484696, 0.0006650699069723487, 0.0007036829483695328, 0.0007096855551935732, 0.0006839811103418469, 0.0006297673680819571, 0.0005522748688235879, 0.00045835517812520266, 0.00035595224471762776, 0.0002534970117267221, 0.00015927103231661022, 8.078764949459583e-05, 2.423608566459734e-05, -5.969956418994116e-06, -7.5066095632791985e-06, 1.9705195882124826e-05, 7.351431850111112e-05, 0.0001497208868386224, 0.00024240957282017916, 0.0003444083849899471, 0.00044783749035559595, 0.0005447060102596879, 0.0006275122868828475, 0.00068980164360255, 0.0007266419124789536, 0.0007349794614128768, 0.0007138532819226384, 0.000664449529722333, 0.0005899956449866295, 0.0004955028998665512, 0.0003873779496643692, 0.00027293365565128624, 0.00015983691264409572, 5.553503433475271e-05, -3.329598985146731e-05, -0.00010124038817593828, -0.00014453264884650707, -0.00016132043674588203, -0.00015178199100773782, -0.00011809048010036349, -6.422933074645698e-05, 4.325972895458108e-06, 8.103494474198669e-05, 0.00015879474813118577, 0.00023048033472150564, 0.0002894811623264104, 0.00033019448164850473, 0.00034843856701627374, 0.00034175600740127265, 0.0003095846332143992, 0.00025328577612526715, 0.00017602772277314216, 8.253537089331076e-05, -2.127450170519296e-05, -0.00012874361709691584, -0.00023297398001886904, -0.0003273431211709976, -0.0004059937782585621, -0.0004642622370738536, -0.000499012996442616, -0.000508856785017997, -0.0004942353698424995, -0.0004573693440761417, -0.0004020732012577355, -0.000333453033817932, -0.00025751092471182346, -0.00018068608187604696, -0.00010936755279544741, -4.9415833927923813e-05, -5.728490577894263e-06, 1.8117911167792045e-05, 2.0123445210629143e-05, 4.064368741885494e-19, -4.0823055314831436e-05, -9.932186367223039e-05, -0.00017111931811086833, -0.0002508255129214376, -0.00033245052327401936, -0.0004098587960470468, -0.00047722976887598634, -0.0005294909351505339, -0.0005626911879517138, -0.0005742861540056765, -0.0005633165710605681, -0.0005304660880938172, -0.000477995810797438, -0.000409561675041914, -0.00032992937485687435, -0.0002446091384626925, -0.00015943868493195623, -8.014516060939059e-05, -1.1920506949536502e-05, 4.095953772775829e-05, 7.544393884018064e-05, 8.992021321319044e-05, 8.431856986135244e-05, 6.009963544784114e-05, 2.0127688912907615e-05, -3.1559786293655634e-05, -9.006814798340201e-05, -0.00015002272266428918, -0.0002059781108982861, -0.00025282881688326597, -0.00028619071235880256, -0.0003027241909876466, -0.00030037687974981964, -0.00027852688799612224, -0.00023801835777703673, -0.00018108633230440319, -0.00011117885151179507, -3.268964428571053e-05, 4.937703852192499e-05, 0.00012978422455489635, 0.00020345367374829948, 0.00026584166334941983, 0.00031327109900303185, 0.0003431958903092891, 0.00035437781480140984, 0.0003469642251729965, 0.000322461302857846, 0.00028360620490275323, 0.00023414820316247642, 0.0001785569911589846, 0.00012167946988483891, 6.837237015133724e-05, 2.3137663447414525e-05, -1.0211662811343558e-05, -2.8830803785240278e-05, -3.104707138845697e-05, -1.6473983123432845e-05, 1.3972140550322365e-05, 5.815325494040735e-05, 0.0001128813746618107, 0.00017416727496311069, 0.0002375266922172159, 0.0002983206941280514, 0.0003521041653584689, 0.00039495647069998085, 0.000423769757617265, 0.00043647337588481605, 0.0004321791639085859, 0.00041123604751192033, 0.00037519275792874396, 0.00032667029881849885, 0.0002691563859116286, 0.0002067368186544627, 0.000143785189720802, 8.463420817861333e-05, 3.325360012240708e-05, -7.041494427539874e-06, -3.383009971003048e-05, -4.575560524244793e-05, -4.261452704668045e-05, -2.535810199333355e-05, 3.992569418187486e-06, 4.251053906045854e-05, 8.659312879899517e-05, 0.0001322402385994792, 0.00017535951337777078, 0.0002120753051713109, 0.00023901823442429304, 0.0002535738458391279, 0.00025407233624719083, 0.00023990565387066454, 0.0002115638490067795, 0.00017058908997569233, 0.00011945151345571503, 6.13565935054794e-05, -2.7772325402647653e-19, -6.071198367862962e-05, -0.00011695479770423844, -0.00016526876424904913, -0.00020281216711737216, -0.00022756530961487442, -0.00023847116972319782, -0.0002355025935685262, -0.0002196518616983667, -0.00019284414884168655, -0.00015778219676576555, -0.00011773466394515708, -7.62844574637711e-05, -3.705619747051969e-05, -3.4437225622241385e-06, 2.164230500056874e-05, 3.5987799492431805e-05, 3.82342332159169e-05, 2.7971873350907117e-05, 5.760933618148556e-06, -2.6920066375168972e-05, -6.779417890356854e-05, -0.00011396440822863951, -0.00016213661001529545, -0.00020886980928480625, -0.0002508348261471838, -0.00028506203670985997, -0.0003091593680437654, -0.00032148498576134443, -0.0003212622832506895, -0.0003086288343183696, -0.00028461628244258463, -0.0002510643098503351, -0.00021047471091151237, -0.0001658177498029545, -0.0001203057836391963, -7.715124229434878e-05, -3.932734398404136e-05, -9.349378160550259e-06, 1.0907290743489284e-05, 2.0339328330010176e-05, 1.8688288037083112e-05, 6.549456429638667e-06, -1.4683294466522057e-05, -4.2931798816425726e-05, -7.559780351584777e-05, -0.00010976435441989452, -0.000142418677569367, -0.00017067995213437825, -0.0001920145732583478, -0.00020442312234081328, -0.0002065853914245963, -0.00019795291882473975, -0.00017878285143524408, -0.0001501112274127081, -0.00011366826220182702, -7.17427465133369e-05, -2.700613549677655e-05, 1.7689993910607882e-05, 5.9527639677980915e-05, 9.593122376827523e-05, 0.0001247559703188017, 0.0001444419613108039, 0.00015412276843562722, 0.00015368104504887015, 0.00014374747115653008, 0.00012564392818603665, 0.0001012755892588757, 7.298075070139021e-05, 4.3349951738491654e-05, 1.5028518646431621e-05, -9.482860150455963e-06, -2.801425762299914e-05, -3.888579158228822e-05, -4.102833918295801e-05, -3.405714960535988e-05, -1.8293419998371974e-05, 5.267310370982159e-06, 3.503678090055473e-05, 6.895912520121783e-05, 0.00010466953972354531, 0.00013967427366878837, 0.00017153826775029302, 0.0001980662054847926, 0.00021746366110164672, 0.00022846661158837378, 0.00023042940301820636, 0.00022336610709317029, 0.00020794167357962579, 0.00018541482859291136, 0.0001575372734805569, 0.00012641726061701775, 9.435815445613116e-05, 6.36844415566884e-05, 3.6568206269294024e-05, 1.4869176084175706e-05, 4.759688234497502e-19, -7.17336661182344e-06, -6.38918436379754e-06, 1.9984447590104537e-06, 1.7054169802577235e-05, 3.733905396074988e-05, 6.102500992710702e-05, 8.603695459896699e-05, 0.00011021178215742111, 0.00013146201672498137, 0.00014793191803619266, 0.0001581342949066311, 0.0001610582257853821, 0.00015623995568603277, 0.00014379181084223092, 0.000124387996038422, 9.920832962961867e-05, 6.984508945606649e-05, 3.817994365817867e-05, 6.240906714083394e-06, -2.3949956812430173e-05, -5.0526530685601756e-05, -7.19151648809202e-05, -8.694765710970387e-05, -9.494254481978714e-05, -9.574909199727699e-05, -8.975099626695737e-05, -7.783022010698915e-05, -6.12939620623365e-05, -4.177083246759139e-05, -2.1084328182041645e-05, -1.1133173529742635e-06, 1.6349844372598454e-05, 2.9732904295087792e-05, 3.779915641644038e-05, 3.973634011344984e-05, 3.521261169225909e-05, 2.4395909349550493e-05, 7.935660505609121e-06, -1.3091317669022828e-05, -3.7266232538968325e-05, -6.293825572356582e-05, -8.835042535793036e-05, -0.00011177201668033376, -0.00013162723917048424, -0.00014661080786027014, -0.00015578184684272856, -0.00015862945292610675, -0.00015510529919993132, -0.00014562129217665642, -0.00013101288641337305, -0.00011247133807046339, -9.1450237960089e-05, -6.955358549021184e-05, -4.8414287448395044e-05, -2.957200922537595e-05, -1.4359578017320018e-05, -3.806434506259393e-06, 1.433989268662117e-06, 1.1278054898866685e-06, -4.527756118477555e-06, -1.492517640144797e-05, -2.9097900551278144e-05, -4.579779124469496e-05, -6.359260441968217e-05, -8.097604586509988e-05, -9.648183186072856e-05, -0.00010879342153202742, -0.00011684091441566125, -0.0001198785612359643, -0.00011753669241443276, -0.00010984512482536957, -9.722632239572704e-05, -8.04592709755525e-05, -6.06172761763446e-05, -3.8984533603070304e-05, -1.6958128981059417e-05, 4.057182195538189e-06, 2.2753249140805565e-05, 3.801426646532491e-05, 4.8996804252965376e-05, 5.518843681784347e-05, 5.6440840126015246e-05, 5.2975257858633995e-05, 4.536025880952366e-05, 3.446387199801393e-05, 2.138402487616986e-05, 7.362746146100108e-06, -6.309201580734225e-06, -1.8390001059742644e-05, -2.7779446099884808e-05, -3.359971378813498e-05, -3.525840293150395e-05, -3.248933353461325e-05, -2.536837746447418e-05, -1.4303484022093471e-05, -3.86560602948301e-19, 1.6595782653894275e-05, 3.4370332286925986e-05, 5.212807809584774e-05, 6.868159107398242e-05, 8.293991413665935e-05, 9.398848487762734e-05, 0.00010115483746631071, 0.00010405515786260366, 0.00010261887655360624, 9.708934521768242e-05, 8.80012012203224e-05, 7.613624620717019e-05, 6.246151315281168e-05, 4.805449862033129e-05, 3.402110087336041e-05, 2.1412737623904832e-05, 1.11487124740961e-05, 3.949597612518119e-06, 2.8644902272390027e-07, 3.4943451510116574e-07, 4.037917278765235e-06, 1.0972444215440191e-05, 2.0527410015347414e-05, 3.188167465850711e-05, 4.408307358971797e-05, 5.612176755676046e-05, 6.70069275656715e-05, 7.584079867228866e-05, 8.188482752302662e-05, 8.461284596705809e-05, 8.374772005481645e-05, 7.927881233626977e-05, 7.14592169970274e-05, 6.078349906601943e-05, 4.794755659531802e-05, 3.3794156479416415e-05, 1.9248280295869336e-05, 5.247271019470645e-06, -7.328868832701119e-06, -1.7721862604958005e-05, -2.5349487259518355e-05, -2.984591446875129e-05, -3.108531382167712e-05, -2.918712198152207e-05, -2.4502976884832606e-05, -1.758645157678984e-05, -9.148187018581666e-06, -5.063597428853296e-20, 9.007720109366346e-06, 1.7050531823770143e-05, 2.3391512513626367e-05, 2.7435326046543196e-05, 2.8770880817319266e-05, 2.7199545002076775e-05, 2.2747004550183192e-05, 1.5658211850677617e-05, 6.37597986496985e-06, -4.494898803386604e-06, -1.623506614123471e-05, -2.806587508530356e-05, -3.9208243833854795e-05, -4.894063749816269e-05, -5.665184653480537e-05, -6.188475526869297e-05, -6.436786497943103e-05, -6.403253064490855e-05, -6.101471808506176e-05, -5.5641590734012425e-05, -4.8403879191027954e-05, -3.9916652895044535e-05, -3.087131699430756e-05, -2.1982814359944314e-05, -1.3935844435764011e-05, -7.334280326176668e-06, -2.6574471121421084e-06, -2.264248024630433e-07, -1.8274870683399058e-07, -2.480883495081798e-06, -6.8948133957746904e-06, -1.3038024917477742e-05, -2.0395171304699033e-05, -2.8362848752294667e-05, -3.62963110092096e-05, -4.355849523562938e-05, -4.9567690439289436e-05, -5.384029645938426e-05, -5.602551391348243e-05, -5.592962770606391e-05, -5.3528070566244423e-05, -4.896469181403518e-05, -4.253848237567581e-05, -3.467890928732231e-05, -2.591194788692519e-05, -1.681944922893308e-05, -7.995062333066016e-06, -4.971666966643111e-20, 6.6780053202819545e-06, 1.1659562005661428e-05, 1.4699785424454603e-05, 1.570396671013441e-05, 1.4731761439179536e-05, 1.1989768609055318e-05, 7.813269803591538e-06, 2.6386685476609273e-06, -3.0311339287436567e-06, -8.665725545142777e-06, -1.3747543562203646e-05, -1.781055107130669e-05, -2.047438101726584e-05, -2.147148370568175e-05, -2.0665334886871278e-05, -1.805854481062852e-05, -1.3790404409519397e-05, -8.124261512421072e-06, -1.4258359897212358e-06, 5.865727871423587e-06, 1.3271796888147946e-05, 2.0310537365730852e-05, 2.653278897923883e-05, 3.155487866024487e-05, 3.508594454615377e-05, 3.6947876651538536e-05, 3.708642179844901e-05, 3.557290619937703e-05, 3.2596544770058244e-05, 2.844804839696735e-05, 2.3496044377679937e-05, 1.81580562639283e-05, 1.2868410522060003e-05, 8.045493814279325e-06, 4.060822448082035e-06, 1.212198981193069e-06, -2.9710781745961867e-07, -3.7171261624280305e-07, 9.708536481412011e-07, 3.603656296036206e-06, 7.301986443053465e-06, 1.1762086614908185e-05, 1.6625428543193266e-05, 2.1506642951862887e-05, 2.60229116975097e-05, 2.982261503348127e-05, 3.2611129427095875e-05, 3.4171829611295834e-05, 3.438090061536059e-05, 3.321492476970889e-05, 3.075079439440742e-05, 2.715819573495537e-05, 2.2685258954879828e-05, 1.7638651115703396e-05, 1.2359699212538544e-05, 7.198394541774178e-06, 2.48725586970977e-06, -1.4829527117399266e-06, -4.483922566578258e-06, -6.365404260577634e-06, -7.064671535772504e-06, -6.609247520827921e-06, -5.112840426590992e-06, -2.764920964182238e-06, 1.8514899124966178e-07, 3.448134521022439e-06, 6.717510132148163e-06, 9.692865205579437e-06, 1.2102372238587122e-05, 1.3722634321311489e-05, 1.439450807083631e-05, 1.4033787010703236e-05, 1.2636052815651055e-05, 1.0275458407704718e-05, 7.097652542142896e-06, 3.307513679828844e-06, -8.47292596972693e-07, -5.095614142192062e-06, -9.163457434624434e-06, -1.2794411304639652e-05, -1.576832619321067e-05, -1.7916880096890964e-05, -1.913494816108141e-05, -1.9387009160709567e-05, -1.8708204152062535e-05, -1.720011823636014e-05, -1.5021676517790183e-05, -1.237597916770028e-05, -9.494119694863912e-06, -6.617289272980997e-06, -3.978527729486814e-06, -1.7855024907476036e-06, -2.0557799018661171e-07, 6.457555059569131e-07, 7.123069849512831e-07, 8.215078337615332e-20, -1.425026880497171e-06, -3.442784645812935e-06, -5.8896825976262335e-06, -8.5718083937536e-06, -1.128017083829036e-05, -1.38067189254798e-05, -1.5959922166075557e-05, -1.757875179464463e-05, -1.8544056729297154e-05, -1.8786538930726238e-05, -1.829082248150371e-05, -1.7095377188525163e-05, -1.5288447684724815e-05, -1.3000330909562763e-05, -1.0392719559604302e-05, -7.645944606338162e-06, -4.945143246004591e-06, -2.466412524881889e-06, -3.639673877842142e-07, 1.2407316489770892e-06, 2.267136324007879e-06, 2.6805023480847012e-06, 2.493231022526743e-06, 1.762649276315642e-06, 5.854863616150396e-07, -9.104568903239851e-07, -2.5767512852326035e-06, -4.25605367126991e-06, -5.794186108687427e-06, -7.051662578305695e-06, -7.913810804893728e-06, -8.298771717818454e-06, -8.162829544744454e-06, -7.502730113628786e-06, -6.3549282458552625e-06, -4.7918524614942726e-06, -2.915590812335722e-06, -8.495126166963018e-07, 1.2714757531284704e-06, 3.3112808068835875e-06, 5.142777808941901e-06, 6.657021003775299e-06, 7.770840056764428e-06, 8.432297363469843e-06, 8.62365686771227e-06, 8.36170875118114e-06, 7.695504791627172e-06, 6.7017367655353155e-06, 5.478191269503441e-06, 4.1358016460435465e-06, 2.789958898574696e-06, 1.551741092953307e-06, 5.197276777835214e-07, -2.2700196211644652e-07, -6.341982157209713e-07, -6.757429673598381e-07, -3.547388871538715e-07, 2.976310611302324e-07, 1.2253200338818715e-06, 2.352405545025249e-06, 3.589418611227302e-06, 4.84049814986065e-06, 6.01080273554544e-06, 7.0136188696778845e-06, 7.776633538014721e-06, 8.246925062849186e-06, 8.394348697038367e-06, 8.21308458398562e-06, 7.721328984189313e-06, 6.959172424103599e-06, 5.98491214987007e-06, 4.870114480581833e-06, 3.6938463381375186e-06, 2.536532065278152e-06, 1.4739226799065364e-06, 5.716180453418929e-07, -1.194551799699184e-07, -5.663034130520828e-07, -7.556611762993271e-07, -6.942357799744059e-07, -4.074368575857079e-07, 6.325814183583134e-08, 6.640565288762446e-07, 1.333393925051496e-06, 2.0068987396371085e-06, 2.622382453409955e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_1_1</value></param>
<param><key>value</key><value>[2.622382453409955e-06, 2.0068987396371085e-06, 1.333393925051496e-06, 6.640565288762446e-07, 6.325814183583134e-08, -4.074368575857079e-07, -6.942357799744059e-07, -7.556611762993271e-07, -5.663034130520828e-07, -1.194551799699184e-07, 5.716180453418929e-07, 1.4739226799065364e-06, 2.536532065278152e-06, 3.6938463381375186e-06, 4.870114480581833e-06, 5.98491214987007e-06, 6.959172424103599e-06, 7.721328984189313e-06, 8.21308458398562e-06, 8.394348697038367e-06, 8.246925062849186e-06, 7.776633538014721e-06, 7.0136188696778845e-06, 6.01080273554544e-06, 4.84049814986065e-06, 3.589418611227302e-06, 2.352405545025249e-06, 1.2253200338818715e-06, 2.976310611302324e-07, -3.547388871538715e-07, -6.757429673598381e-07, -6.341982157209713e-07, -2.2700196211644652e-07, 5.197276777835214e-07, 1.551741092953307e-06, 2.789958898574696e-06, 4.1358016460435465e-06, 5.478191269503441e-06, 6.7017367655353155e-06, 7.695504791627172e-06, 8.36170875118114e-06, 8.62365686771227e-06, 8.432297363469843e-06, 7.770840056764428e-06, 6.657021003775299e-06, 5.142777808941901e-06, 3.3112808068835875e-06, 1.2714757531284704e-06, -8.495126166963018e-07, -2.915590812335722e-06, -4.7918524614942726e-06, -6.3549282458552625e-06, -7.502730113628786e-06, -8.162829544744454e-06, -8.298771717818454e-06, -7.913810804893728e-06, -7.051662578305695e-06, -5.794186108687427e-06, -4.25605367126991e-06, -2.5767512852326035e-06, -9.104568903239851e-07, 5.854863616150396e-07, 1.762649276315642e-06, 2.493231022526743e-06, 2.6805023480847012e-06, 2.267136324007879e-06, 1.2407316489770892e-06, -3.639673877842142e-07, -2.466412524881889e-06, -4.945143246004591e-06, -7.645944606338162e-06, -1.0392719559604302e-05, -1.3000330909562763e-05, -1.5288447684724815e-05, -1.7095377188525163e-05, -1.829082248150371e-05, -1.8786538930726238e-05, -1.8544056729297154e-05, -1.757875179464463e-05, -1.5959922166075557e-05, -1.38067189254798e-05, -1.128017083829036e-05, -8.5718083937536e-06, -5.8896825976262335e-06, -3.442784645812935e-06, -1.425026880497171e-06, 8.215078337615332e-20, 7.123069849512831e-07, 6.457555059569131e-07, -2.0557799018661171e-07, -1.7855024907476036e-06, -3.978527729486814e-06, -6.617289272980997e-06, -9.494119694863912e-06, -1.237597916770028e-05, -1.5021676517790183e-05, -1.720011823636014e-05, -1.8708204152062535e-05, -1.9387009160709567e-05, -1.913494816108141e-05, -1.7916880096890964e-05, -1.576832619321067e-05, -1.2794411304639652e-05, -9.163457434624434e-06, -5.095614142192062e-06, -8.47292596972693e-07, 3.307513679828844e-06, 7.097652542142896e-06, 1.0275458407704718e-05, 1.2636052815651055e-05, 1.4033787010703236e-05, 1.439450807083631e-05, 1.3722634321311489e-05, 1.2102372238587122e-05, 9.692865205579437e-06, 6.717510132148163e-06, 3.448134521022439e-06, 1.8514899124966178e-07, -2.764920964182238e-06, -5.112840426590992e-06, -6.609247520827921e-06, -7.064671535772504e-06, -6.365404260577634e-06, -4.483922566578258e-06, -1.4829527117399266e-06, 2.48725586970977e-06, 7.198394541774178e-06, 1.2359699212538544e-05, 1.7638651115703396e-05, 2.2685258954879828e-05, 2.715819573495537e-05, 3.075079439440742e-05, 3.321492476970889e-05, 3.438090061536059e-05, 3.4171829611295834e-05, 3.2611129427095875e-05, 2.982261503348127e-05, 2.60229116975097e-05, 2.1506642951862887e-05, 1.6625428543193266e-05, 1.1762086614908185e-05, 7.301986443053465e-06, 3.603656296036206e-06, 9.708536481412011e-07, -3.7171261624280305e-07, -2.9710781745961867e-07, 1.212198981193069e-06, 4.060822448082035e-06, 8.045493814279325e-06, 1.2868410522060003e-05, 1.81580562639283e-05, 2.3496044377679937e-05, 2.844804839696735e-05, 3.2596544770058244e-05, 3.557290619937703e-05, 3.708642179844901e-05, 3.6947876651538536e-05, 3.508594454615377e-05, 3.155487866024487e-05, 2.653278897923883e-05, 2.0310537365730852e-05, 1.3271796888147946e-05, 5.865727871423587e-06, -1.4258359897212358e-06, -8.124261512421072e-06, -1.3790404409519397e-05, -1.805854481062852e-05, -2.0665334886871278e-05, -2.147148370568175e-05, -2.047438101726584e-05, -1.781055107130669e-05, -1.3747543562203646e-05, -8.665725545142777e-06, -3.0311339287436567e-06, 2.6386685476609273e-06, 7.813269803591538e-06, 1.1989768609055318e-05, 1.4731761439179536e-05, 1.570396671013441e-05, 1.4699785424454603e-05, 1.1659562005661428e-05, 6.6780053202819545e-06, -4.971666966643111e-20, -7.995062333066016e-06, -1.681944922893308e-05, -2.591194788692519e-05, -3.467890928732231e-05, -4.253848237567581e-05, -4.896469181403518e-05, -5.3528070566244423e-05, -5.592962770606391e-05, -5.602551391348243e-05, -5.384029645938426e-05, -4.9567690439289436e-05, -4.355849523562938e-05, -3.62963110092096e-05, -2.8362848752294667e-05, -2.0395171304699033e-05, -1.3038024917477742e-05, -6.8948133957746904e-06, -2.480883495081798e-06, -1.8274870683399058e-07, -2.264248024630433e-07, -2.6574471121421084e-06, -7.334280326176668e-06, -1.3935844435764011e-05, -2.1982814359944314e-05, -3.087131699430756e-05, -3.9916652895044535e-05, -4.8403879191027954e-05, -5.5641590734012425e-05, -6.101471808506176e-05, -6.403253064490855e-05, -6.436786497943103e-05, -6.188475526869297e-05, -5.665184653480537e-05, -4.894063749816269e-05, -3.9208243833854795e-05, -2.806587508530356e-05, -1.623506614123471e-05, -4.494898803386604e-06, 6.37597986496985e-06, 1.5658211850677617e-05, 2.2747004550183192e-05, 2.7199545002076775e-05, 2.8770880817319266e-05, 2.7435326046543196e-05, 2.3391512513626367e-05, 1.7050531823770143e-05, 9.007720109366346e-06, -5.063597428853296e-20, -9.148187018581666e-06, -1.758645157678984e-05, -2.4502976884832606e-05, -2.918712198152207e-05, -3.108531382167712e-05, -2.984591446875129e-05, -2.5349487259518355e-05, -1.7721862604958005e-05, -7.328868832701119e-06, 5.247271019470645e-06, 1.9248280295869336e-05, 3.3794156479416415e-05, 4.794755659531802e-05, 6.078349906601943e-05, 7.14592169970274e-05, 7.927881233626977e-05, 8.374772005481645e-05, 8.461284596705809e-05, 8.188482752302662e-05, 7.584079867228866e-05, 6.70069275656715e-05, 5.612176755676046e-05, 4.408307358971797e-05, 3.188167465850711e-05, 2.0527410015347414e-05, 1.0972444215440191e-05, 4.037917278765235e-06, 3.4943451510116574e-07, 2.8644902272390027e-07, 3.949597612518119e-06, 1.11487124740961e-05, 2.1412737623904832e-05, 3.402110087336041e-05, 4.805449862033129e-05, 6.246151315281168e-05, 7.613624620717019e-05, 8.80012012203224e-05, 9.708934521768242e-05, 0.00010261887655360624, 0.00010405515786260366, 0.00010115483746631071, 9.398848487762734e-05, 8.293991413665935e-05, 6.868159107398242e-05, 5.212807809584774e-05, 3.4370332286925986e-05, 1.6595782653894275e-05, -3.86560602948301e-19, -1.4303484022093471e-05, -2.536837746447418e-05, -3.248933353461325e-05, -3.525840293150395e-05, -3.359971378813498e-05, -2.7779446099884808e-05, -1.8390001059742644e-05, -6.309201580734225e-06, 7.362746146100108e-06, 2.138402487616986e-05, 3.446387199801393e-05, 4.536025880952366e-05, 5.2975257858633995e-05, 5.6440840126015246e-05, 5.518843681784347e-05, 4.8996804252965376e-05, 3.801426646532491e-05, 2.2753249140805565e-05, 4.057182195538189e-06, -1.6958128981059417e-05, -3.8984533603070304e-05, -6.06172761763446e-05, -8.04592709755525e-05, -9.722632239572704e-05, -0.00010984512482536957, -0.00011753669241443276, -0.0001198785612359643, -0.00011684091441566125, -0.00010879342153202742, -9.648183186072856e-05, -8.097604586509988e-05, -6.359260441968217e-05, -4.579779124469496e-05, -2.9097900551278144e-05, -1.492517640144797e-05, -4.527756118477555e-06, 1.1278054898866685e-06, 1.433989268662117e-06, -3.806434506259393e-06, -1.4359578017320018e-05, -2.957200922537595e-05, -4.8414287448395044e-05, -6.955358549021184e-05, -9.1450237960089e-05, -0.00011247133807046339, -0.00013101288641337305, -0.00014562129217665642, -0.00015510529919993132, -0.00015862945292610675, -0.00015578184684272856, -0.00014661080786027014, -0.00013162723917048424, -0.00011177201668033376, -8.835042535793036e-05, -6.293825572356582e-05, -3.7266232538968325e-05, -1.3091317669022828e-05, 7.935660505609121e-06, 2.4395909349550493e-05, 3.521261169225909e-05, 3.973634011344984e-05, 3.779915641644038e-05, 2.9732904295087792e-05, 1.6349844372598454e-05, -1.1133173529742635e-06, -2.1084328182041645e-05, -4.177083246759139e-05, -6.12939620623365e-05, -7.783022010698915e-05, -8.975099626695737e-05, -9.574909199727699e-05, -9.494254481978714e-05, -8.694765710970387e-05, -7.19151648809202e-05, -5.0526530685601756e-05, -2.3949956812430173e-05, 6.240906714083394e-06, 3.817994365817867e-05, 6.984508945606649e-05, 9.920832962961867e-05, 0.000124387996038422, 0.00014379181084223092, 0.00015623995568603277, 0.0001610582257853821, 0.0001581342949066311, 0.00014793191803619266, 0.00013146201672498137, 0.00011021178215742111, 8.603695459896699e-05, 6.102500992710702e-05, 3.733905396074988e-05, 1.7054169802577235e-05, 1.9984447590104537e-06, -6.38918436379754e-06, -7.17336661182344e-06, 4.759688234497502e-19, 1.4869176084175706e-05, 3.6568206269294024e-05, 6.36844415566884e-05, 9.435815445613116e-05, 0.00012641726061701775, 0.0001575372734805569, 0.00018541482859291136, 0.00020794167357962579, 0.00022336610709317029, 0.00023042940301820636, 0.00022846661158837378, 0.00021746366110164672, 0.0001980662054847926, 0.00017153826775029302, 0.00013967427366878837, 0.00010466953972354531, 6.895912520121783e-05, 3.503678090055473e-05, 5.267310370982159e-06, -1.8293419998371974e-05, -3.405714960535988e-05, -4.102833918295801e-05, -3.888579158228822e-05, -2.801425762299914e-05, -9.482860150455963e-06, 1.5028518646431621e-05, 4.3349951738491654e-05, 7.298075070139021e-05, 0.0001012755892588757, 0.00012564392818603665, 0.00014374747115653008, 0.00015368104504887015, 0.00015412276843562722, 0.0001444419613108039, 0.0001247559703188017, 9.593122376827523e-05, 5.9527639677980915e-05, 1.7689993910607882e-05, -2.700613549677655e-05, -7.17427465133369e-05, -0.00011366826220182702, -0.0001501112274127081, -0.00017878285143524408, -0.00019795291882473975, -0.0002065853914245963, -0.00020442312234081328, -0.0001920145732583478, -0.00017067995213437825, -0.000142418677569367, -0.00010976435441989452, -7.559780351584777e-05, -4.2931798816425726e-05, -1.4683294466522057e-05, 6.549456429638667e-06, 1.8688288037083112e-05, 2.0339328330010176e-05, 1.0907290743489284e-05, -9.349378160550259e-06, -3.932734398404136e-05, -7.715124229434878e-05, -0.0001203057836391963, -0.0001658177498029545, -0.00021047471091151237, -0.0002510643098503351, -0.00028461628244258463, -0.0003086288343183696, -0.0003212622832506895, -0.00032148498576134443, -0.0003091593680437654, -0.00028506203670985997, -0.0002508348261471838, -0.00020886980928480625, -0.00016213661001529545, -0.00011396440822863951, -6.779417890356854e-05, -2.6920066375168972e-05, 5.760933618148556e-06, 2.7971873350907117e-05, 3.82342332159169e-05, 3.5987799492431805e-05, 2.164230500056874e-05, -3.4437225622241385e-06, -3.705619747051969e-05, -7.62844574637711e-05, -0.00011773466394515708, -0.00015778219676576555, -0.00019284414884168655, -0.0002196518616983667, -0.0002355025935685262, -0.00023847116972319782, -0.00022756530961487442, -0.00020281216711737216, -0.00016526876424904913, -0.00011695479770423844, -6.071198367862962e-05, -2.7772325402647653e-19, 6.13565935054794e-05, 0.00011945151345571503, 0.00017058908997569233, 0.0002115638490067795, 0.00023990565387066454, 0.00025407233624719083, 0.0002535738458391279, 0.00023901823442429304, 0.0002120753051713109, 0.00017535951337777078, 0.0001322402385994792, 8.659312879899517e-05, 4.251053906045854e-05, 3.992569418187486e-06, -2.535810199333355e-05, -4.261452704668045e-05, -4.575560524244793e-05, -3.383009971003048e-05, -7.041494427539874e-06, 3.325360012240708e-05, 8.463420817861333e-05, 0.000143785189720802, 0.0002067368186544627, 0.0002691563859116286, 0.00032667029881849885, 0.00037519275792874396, 0.00041123604751192033, 0.0004321791639085859, 0.00043647337588481605, 0.000423769757617265, 0.00039495647069998085, 0.0003521041653584689, 0.0002983206941280514, 0.0002375266922172159, 0.00017416727496311069, 0.0001128813746618107, 5.815325494040735e-05, 1.3972140550322365e-05, -1.6473983123432845e-05, -3.104707138845697e-05, -2.8830803785240278e-05, -1.0211662811343558e-05, 2.3137663447414525e-05, 6.837237015133724e-05, 0.00012167946988483891, 0.0001785569911589846, 0.00023414820316247642, 0.00028360620490275323, 0.000322461302857846, 0.0003469642251729965, 0.00035437781480140984, 0.0003431958903092891, 0.00031327109900303185, 0.00026584166334941983, 0.00020345367374829948, 0.00012978422455489635, 4.937703852192499e-05, -3.268964428571053e-05, -0.00011117885151179507, -0.00018108633230440319, -0.00023801835777703673, -0.00027852688799612224, -0.00030037687974981964, -0.0003027241909876466, -0.00028619071235880256, -0.00025282881688326597, -0.0002059781108982861, -0.00015002272266428918, -9.006814798340201e-05, -3.1559786293655634e-05, 2.0127688912907615e-05, 6.009963544784114e-05, 8.431856986135244e-05, 8.992021321319044e-05, 7.544393884018064e-05, 4.095953772775829e-05, -1.1920506949536502e-05, -8.014516060939059e-05, -0.00015943868493195623, -0.0002446091384626925, -0.00032992937485687435, -0.000409561675041914, -0.000477995810797438, -0.0005304660880938172, -0.0005633165710605681, -0.0005742861540056765, -0.0005626911879517138, -0.0005294909351505339, -0.00047722976887598634, -0.0004098587960470468, -0.00033245052327401936, -0.0002508255129214376, -0.00017111931811086833, -9.932186367223039e-05, -4.0823055314831436e-05, 4.064368741885494e-19, 2.0123445210629143e-05, 1.8117911167792045e-05, -5.728490577894263e-06, -4.9415833927923813e-05, -0.00010936755279544741, -0.00018068608187604696, -0.00025751092471182346, -0.000333453033817932, -0.0004020732012577355, -0.0004573693440761417, -0.0004942353698424995, -0.000508856785017997, -0.000499012996442616, -0.0004642622370738536, -0.0004059937782585621, -0.0003273431211709976, -0.00023297398001886904, -0.00012874361709691584, -2.127450170519296e-05, 8.253537089331076e-05, 0.00017602772277314216, 0.00025328577612526715, 0.0003095846332143992, 0.00034175600740127265, 0.00034843856701627374, 0.00033019448164850473, 0.0002894811623264104, 0.00023048033472150564, 0.00015879474813118577, 8.103494474198669e-05, 4.325972895458108e-06, -6.422933074645698e-05, -0.00011809048010036349, -0.00015178199100773782, -0.00016132043674588203, -0.00014453264884650707, -0.00010124038817593828, -3.329598985146731e-05, 5.553503433475271e-05, 0.00015983691264409572, 0.00027293365565128624, 0.0003873779496643692, 0.0004955028998665512, 0.0005899956449866295, 0.000664449529722333, 0.0007138532819226384, 0.0007349794614128768, 0.0007266419124789536, 0.00068980164360255, 0.0006275122868828475, 0.0005447060102596879, 0.00044783749035559595, 0.0003444083849899471, 0.00024240957282017916, 0.0001497208868386224, 7.351431850111112e-05, 1.9705195882124826e-05, -7.5066095632791985e-06, -5.969956418994116e-06, 2.423608566459734e-05, 8.078764949459583e-05, 0.00015927103231661022, 0.0002534970117267221, 0.00035595224471762776, 0.00045835517812520266, 0.0005522748688235879, 0.0006297673680819571, 0.0006839811103418469, 0.0007096855551935732, 0.0007036829483695328, 0.0006650699069723487, 0.0005953291547484696, 0.0004982416867278516, 0.0003796251257881522, 0.0002469161117915064, 0.00010862691851798445, -2.6283949409844354e-05, -0.00014908025332260877, -0.00025190567248500884, -0.000328380789142102, -0.0003740942047443241, -0.0003869487263727933, -0.00036733667366206646, -0.0003181281790602952, -0.0002444727288093418, -0.00015342628466896713, -5.343164229998365e-05, 4.631117917597294e-05, 0.00013653698260895908, 0.0002086188760586083, 0.00025522991199977696, 0.0002709125983528793, 0.00025251219631172717, 0.0001994407211896032, 0.00011374888708814979, -2.582592082444939e-18, -0.00013504714297596365, -0.0002829238655976951, -0.00043407068005762994, -0.0005785445682704449, -0.000706760969478637, -0.0008102164138108492, -0.000882135471329093, -0.0009179930784739554, -0.0009158727480098605, -0.0008766305400058627, -0.0008038514642976224, -0.000703600060660392, -0.0005839817458763719, -0.0004545464471448213, -0.000325578119372949, -0.00020732272241730243, -0.00010921256034635007, -3.914525223081e-05, -2.8724823550874135e-06, -3.5453977034194395e-06, -4.145253842580132e-05, -0.00011397171329008415, -0.00021574132551904768, -0.00033904032898135483, -0.0004743497120216489, -0.0006110551184974611, -0.000738238450139761, -0.0008454996859654784, -0.0009237474878318608, -0.0009658979251980782, -0.0009674285538494587, -0.0009267440182156861, -0.0008453248883597553, -0.0007276453543454409, -0.0005808650166727602, -0.00041431537829339504, -0.0002388186112511903, -6.588744872715324e-05, 9.31333561311476e-05, 0.0002279202890349552, 0.00032995472429320216, 0.00039317685877904296, 0.00041445993701927364, 0.0003938667068723589, 0.000334667885908857, 0.00024311791639775038, 0.00012800410331692547, -3.585707497240672e-19, -0.00012912903912365437, -0.0002474099164828658, -0.0003435692342463881, -0.0004078962665516883, -0.00043299535172991455, -0.00041437073377892375, -0.0003507970250211656, -0.00024444726295769215, -0.00010076465696329251, 7.191288750618696e-05, 0.0002629501686897129, 0.000460190640296787, 0.0006508539663627744, 0.0008224890916608274, 0.000963909609708935, 0.0010660437401384115, 0.0011226311326026917, 0.0011307138483971357, 0.0010908835101872683, 0.0010072625009343028, 0.0008872179896570742, 0.0007408307865262032, 0.0005801531951874495, 0.0004183128767181188, 0.00026852800510823727, 0.00014310679398477077, 5.250755566521548e-05, 4.530474598141154e-06, 3.702923322634888e-06, 5.09067831444554e-05, 0.000143277837196365, 0.0002743872464634478, 0.00043469376396387815, 0.0006122353370301425, 0.0007935093017295003, 0.0009644774254411459, 0.0011116195237264037, 0.0012229590211063623, 0.0012889798963442445, 0.001303367898799479, 0.0012635146267712116, 0.0011707505909726024, 0.0010302795562893152, 0.000850823475047946, 0.0006439975113607943, 0.00042346285772509873, 0.00020391734142322093, 8.831717444337061e-19, -0.00017480948008596897, -0.00030921297729946673, -0.00039496031240560114, -0.0004274924867786467, -0.00040631258161738515, -0.0003350524348206818, -0.0002212285326095298, -7.570237357867882e-05, 8.811630686977878e-05, 0.00025526591343805194, 0.00041035524918697774, 0.0005387280252762139, 0.0006275824271142483, 0.0006669608410447836, 0.0006505335331894457, 0.0005761156789958477, 0.0004458762414287776, 0.00026622108998708427, 4.7354409616673365e-05, -0.00019744950986932963, -0.00045281247003003955, -0.0007023857324384153, -0.0009300668025389314, -0.0011212077224627137, -0.0012637254549190402, -0.0013490266865119338, -0.001372679602354765, -0.001334776752628386, -0.001239960198290646, -0.0010971034644171596, -0.000918672711122781, -0.0007198111852630973, -0.0005172131932340562, -0.00032787275267764926, -0.0001677981053944677, -5.079020047560334e-05, 1.2623094335140195e-05, 1.6014655557228252e-05, -4.241657006787136e-05, -0.0001596649963175878, -0.00032809912227094173, -0.0005359933129511774, -0.0007683733128942549, -0.0010081147775053978, -0.001237213728018105, -0.0014381357468664646, -0.0015951412497088313, -0.0016954878810793161, -0.0017304178327322006, -0.0016958540072664618, -0.001592749380506575, -0.0014270605752244592, -0.001209345064125955, -0.0009540071478113532, -0.0006782486452721059, -0.0004007987445220351, -0.0001405193324899301, 8.501256525050849e-05, 0.000260837230598554, 0.0003757584490813315, 0.00042321564978919923, 0.0004018136241938919, 0.00031546695390716195, 0.00017314482829533517, -1.1767918294935953e-05, -0.00022244901629164815, -0.00043988513061776757, -0.0006442948943004012, -0.0008166226325556636, -0.0009399917908012867, -0.001001005177386105, -0.0009907972998917103, -0.0009057524148374796, -0.0007478339830413461, -0.0005244966014288366, -0.0002481828269083053, 6.45600666757673e-05, 0.00039428132004104555, 0.0007200569962151349, 0.0010210443288087845, 0.001278043957427144, 0.0014749517431482673, 0.0015999908791854978, 0.001646628137677908, 0.0016141030937433243, 0.0015075273113325238, 0.0013375411508604884, 0.0011195510160177946, 0.0008726002997718751, 0.0006179568590596318, 0.0003775192308239639, 0.0001721620064927265, 2.014351775869727e-05, -6.43029052298516e-05, -7.208679744508117e-05, 2.6941533112745066e-18, 0.00014898112567607313, 0.00036585761699825525, 0.0006362261483445764, 0.0009413105435669422, 0.0012593334540724754, 0.001567126833833754, 0.0018418632680550218, 0.0020627763587981462, 0.0022127442061901093, 0.0022796117700636387, 0.002257149899378419, 0.002145579783245921, 0.0019516156753525138, 0.0016880163457244635, 0.0013726806500926614, 0.001027345540933311, 0.0006759846583008766, 0.0003430235665291548, 5.1504961447790265e-05, -0.00017865751578938216, -0.0003322054399177432, -0.0003997239109594375, -0.00037839970900677145, -0.0002722879871726036, -9.206277900375426e-05, 0.00014573441876564175, 0.00041989603778347373, 0.0007061135256662965, 0.0009787911549210548, 0.0012129745446145535, 0.001386249321512878, 0.0014804658712819219, 0.0014831596054136753, 0.0013885560911148787, 0.0011980816489085555, 0.0009203355293720961, 0.0005705216317437589, 0.00016937701730057597, -0.00025832635583356023, -0.0006855986430309713, -0.0010852329432964325, -0.001431841286830604, -0.0017037733923643827, -0.0018847702303901315, -0.0019652280025184155, -0.0019429716048762202, -0.0018234759336337447, -0.0016195118660107255, -0.001350239384919405, -0.0010398091981187463, -0.0007155772764235735, -0.0004060578066855669, -0.00013877150195185095, 6.185238453326747e-05, 0.0001763606705935672, 0.0001918034249683842, 0.00010278524860041216, -8.804354001767933e-05, -0.00037009804509580135, -0.0007255699019879103, -0.0011306904489174485, -0.0015574562130495906, -0.001975691644474864, -0.002355295931920409, -0.0026685064658522606, -0.0028920115437358618, -0.003008743282407522, -0.0030092266388237476, -0.0028923603240400553, -0.00266558350995183, -0.002344394102692604, -0.0019512613071128726, -0.001513996976427734, -0.0010637129889801145, -0.0006325081922113895, -0.0002510589256417006, 5.370632788981311e-05, 0.00026067206636071205, 0.00035618292167782784, 0.00033514376264065504, 0.00020148465409874916, -3.205064422218129e-05, -0.0003447840572334826, -0.0007095901528373361, -0.0010948857525363564, -0.0014669756637886167, -0.001792584778741002, -0.002041381783783436, -0.0021883100271224976, -0.0022155456244945526, -0.002113929484039545, -0.001883762190118432, -0.0015348942251875997, -0.0010860988404601812, -0.0005637642461806536, -3.968857246782505e-18, 0.0005697082378901541, 0.0011091220658272505, 0.001583958393894136, 0.0019644773565232754, 0.002227756194770336, 0.0023594715166836977, 0.0023550516925752163, 0.0022201091051101685, 0.0019701048731803894, 0.0016292707296088338, 0.0012288561556488276, 0.0008048282470554113, 0.0003951916005462408, 3.7124780646990985e-05, -0.00023585089365951717, -0.00039645779179409146, -0.00042580548324622214, -0.00031492504058405757, -6.557149026775733e-05, 0.0003097737208008766, 0.000788709323387593, 0.0013404787750914693, 0.0019281817367300391, 0.0025114750023931265, 0.0030495633836835623, 0.0035042590461671352, 0.0038428776897490025, 0.00404075812548399, 0.004083199426531792, 0.003966675605624914, 0.003699220484122634, 0.003299945266917348, 0.002797718159854412, 0.002229094970971346, 0.0016356443520635366, 0.0010608683805912733, 0.0005469415918923914, 0.00013151293387636542, -0.0001551864406792447, -0.0002927093009930104, -0.0002720473275985569, -9.644226520322263e-05, 0.00021871825447306037, 0.0006469225627370179, 0.0011524091241881251, 0.001692760968580842, 0.0022220350801944733, 0.002694194670766592, 0.0030665933154523373, 0.0033032442443072796, 0.0033776313066482544, 0.0032748389057815075, 0.002992835594341159, 0.0025428037624806166, 0.0019484779331833124, 0.0012445285683497787, 0.0004741043958347291, -0.00031429564114660025, -0.0010703919688239694, -0.0017458717338740826, -0.002298035193234682, -0.0026930635794997215, -0.0029086607974022627, -0.0029358570463955402, -0.002779832109808922, -0.0024596841540187597, -0.002007140778005123, -0.0014643085887655616, -0.0008806033292785287, -0.000309094728436321, 0.0001974763727048412, 0.0005907068261876702, 0.0008302669739350677, 0.0008870781166478992, 0.0007456839084625244, 0.00040562747744843364, -0.00011828373681055382, -0.0007968601421453059, -0.0015885084867477417, -0.0024421727284789085, -0.003301029559224844, -0.004106669686734676, -0.004803457763046026, -0.005342745687812567, -0.005686620250344276, -0.005810894072055817, -0.0057071056216955185, -0.005383368115872145, -0.004863976966589689, -0.004187797661870718, -0.0034055334981530905, -0.0025760598946362734, -0.0017620950238779187, -0.0010255126981064677, -0.00042265685624442995, 4.571349135186528e-18, 0.00020951696205884218, 0.00018917935085482895, -5.9989608416799456e-05, -0.000519031600560993, -0.0011522057466208935, -0.0019094246672466397, -0.002729809610173106, -0.003546118503436446, -0.004289719276130199, -0.004895754624158144, -0.005308101419359446, -0.005483756307512522, -0.005396303255110979, -0.005038193892687559, -0.004421640187501907, -0.00357804330997169, -0.002555962186306715, -0.0014177642296999693, -0.00023517769295722246, 0.0009159311302937567, 0.001961181405931711, 0.0028332823421806097, 0.003477200400084257, 0.0038544919807463884, 0.003946460783481598, 0.0037558842450380325, 0.0033071544021368027, 0.0026447903364896774, 0.0018304110271856189, 0.0009383663418702781, 5.032741682953201e-05, -0.000750772887840867, -0.0013870070688426495, -0.0017914619529619813, -0.0019135319162160158, -0.0017230879748240113, -0.0012131859548389912, -0.00040108372922986746, 0.0006725398125126958, 0.001946143340319395, 0.003341499250382185, 0.00476920697838068, 0.00613515917211771, 0.007347488310188055, 0.008323491550981998, 0.008996007032692432, 0.009318758733570576, 0.009270239621400833, 0.008855828084051609, 0.00810791365802288, 0.007084018085151911, 0.005862978287041187, 0.004539444111287594, 0.0032170796766877174, 0.0020009237341582775, 0.000989487860351801, 0.00026715616695582867, -0.00010252530773868784, -8.215222624130547e-05, 0.00033607103978283703, 0.0011290027759969234, 0.00224352371878922, 0.003599768504500389, 0.005096440203487873, 0.006617865990847349, 0.008042309433221817, 0.009250943548977375, 0.010136849246919155, 0.01061334740370512, 0.010621052235364914, 0.01013305876404047, 0.009157859720289707, 0.007739689666777849, 0.005956218112260103, 0.00391367869451642, 0.0017397375777363777, -0.00042544235475361347, -0.0024393268395215273, -0.00416760565713048, -0.005494488403201103, -0.00633193738758564, -0.006627105176448822, -0.006367393769323826, -0.005582677666097879, -0.0043444386683404446, -0.002761784940958023, -0.0009745490970090032, 0.0008561286958865821, 0.0025591114535927773, 0.003965709824115038, 0.004922383930534124, 0.005302777513861656, 0.0050181858241558075, 0.004025635309517384, 0.0023329041432589293, -5.4940000389082825e-18, -0.002863129833713174, -0.0061026401817798615, -0.009530278854072094, -0.012935775332152843, -0.016101345419883728, -0.0188173558562994, -0.020898066461086273, -0.022196320816874504, -0.02261612005531788, -0.022122055292129517, -0.02074486017227173, -0.018582439050078392, -0.015796195715665817, -0.012602642178535461, -0.0092606907710433, -0.006055331788957119, -0.0032786098308861256, -0.0012091313255950809, -9.139253234025091e-05, -0.00011633031681412831, -0.0014044520212337375, -0.003992782905697823, -0.007826664485037327, -0.012757154181599617, -0.018544435501098633, -0.02486729621887207, -0.031338270753622055, -0.03752380236983299, -0.04296824336051941, -0.04722044989466667, -0.04986129701137543, -0.05053059384226799, -0.04895159602165222, -0.04495156183838844, -0.0384770967066288, -0.029603049159049988, -0.018534336239099503, -0.005600385833531618, 0.008757706731557846, 0.024006666615605354, 0.03954622894525528, 0.05473865196108818, 0.06894094496965408, 0.08153798431158066, 0.091974638402462, 0.09978508949279785, 0.10461755841970444, 0.10625314712524414, 0.10461755841970444, 0.09978508949279785, 0.091974638402462, 0.08153798431158066, 0.06894094496965408, 0.05473865196108818, 0.03954622894525528, 0.024006666615605354, 0.008757706731557846, -0.005600385833531618, -0.018534336239099503, -0.029603049159049988, -0.0384770967066288, -0.04495156183838844, -0.04895159602165222, -0.05053059384226799, -0.04986129701137543, -0.04722044989466667, -0.04296824336051941, -0.03752380236983299, -0.031338270753622055, -0.02486729621887207, -0.018544435501098633, -0.012757154181599617, -0.007826664485037327, -0.003992782905697823, -0.0014044520212337375, -0.00011633031681412831, -9.139253234025091e-05, -0.0012091313255950809, -0.0032786098308861256, -0.006055331788957119, -0.0092606907710433, -0.012602642178535461, -0.015796195715665817, -0.018582439050078392, -0.02074486017227173, -0.022122055292129517, -0.02261612005531788, -0.022196320816874504, -0.020898066461086273, -0.0188173558562994, -0.016101345419883728, -0.012935775332152843, -0.009530278854072094, -0.0061026401817798615, -0.002863129833713174, -5.4940000389082825e-18, 0.0023329041432589293, 0.004025635309517384, 0.0050181858241558075, 0.005302777513861656, 0.004922383930534124, 0.003965709824115038, 0.0025591114535927773, 0.0008561286958865821, -0.0009745490970090032, -0.002761784940958023, -0.0043444386683404446, -0.005582677666097879, -0.006367393769323826, -0.006627105176448822, -0.00633193738758564, -0.005494488403201103, -0.00416760565713048, -0.0024393268395215273, -0.00042544235475361347, 0.0017397375777363777, 0.00391367869451642, 0.005956218112260103, 0.007739689666777849, 0.009157859720289707, 0.01013305876404047, 0.010621052235364914, 0.01061334740370512, 0.010136849246919155, 0.009250943548977375, 0.008042309433221817, 0.006617865990847349, 0.005096440203487873, 0.003599768504500389, 0.00224352371878922, 0.0011290027759969234, 0.00033607103978283703, -8.215222624130547e-05, -0.00010252530773868784, 0.00026715616695582867, 0.000989487860351801, 0.0020009237341582775, 0.0032170796766877174, 0.004539444111287594, 0.005862978287041187, 0.007084018085151911, 0.00810791365802288, 0.008855828084051609, 0.009270239621400833, 0.009318758733570576, 0.008996007032692432, 0.008323491550981998, 0.007347488310188055, 0.00613515917211771, 0.00476920697838068, 0.003341499250382185, 0.001946143340319395, 0.0006725398125126958, -0.00040108372922986746, -0.0012131859548389912, -0.0017230879748240113, -0.0019135319162160158, -0.0017914619529619813, -0.0013870070688426495, -0.000750772887840867, 5.032741682953201e-05, 0.0009383663418702781, 0.0018304110271856189, 0.0026447903364896774, 0.0033071544021368027, 0.0037558842450380325, 0.003946460783481598, 0.0038544919807463884, 0.003477200400084257, 0.0028332823421806097, 0.001961181405931711, 0.0009159311302937567, -0.00023517769295722246, -0.0014177642296999693, -0.002555962186306715, -0.00357804330997169, -0.004421640187501907, -0.005038193892687559, -0.005396303255110979, -0.005483756307512522, -0.005308101419359446, -0.004895754624158144, -0.004289719276130199, -0.003546118503436446, -0.002729809610173106, -0.0019094246672466397, -0.0011522057466208935, -0.000519031600560993, -5.9989608416799456e-05, 0.00018917935085482895, 0.00020951696205884218, 4.571349135186528e-18, -0.00042265685624442995, -0.0010255126981064677, -0.0017620950238779187, -0.0025760598946362734, -0.0034055334981530905, -0.004187797661870718, -0.004863976966589689, -0.005383368115872145, -0.0057071056216955185, -0.005810894072055817, -0.005686620250344276, -0.005342745687812567, -0.004803457763046026, -0.004106669686734676, -0.003301029559224844, -0.0024421727284789085, -0.0015885084867477417, -0.0007968601421453059, -0.00011828373681055382, 0.00040562747744843364, 0.0007456839084625244, 0.0008870781166478992, 0.0008302669739350677, 0.0005907068261876702, 0.0001974763727048412, -0.000309094728436321, -0.0008806033292785287, -0.0014643085887655616, -0.002007140778005123, -0.0024596841540187597, -0.002779832109808922, -0.0029358570463955402, -0.0029086607974022627, -0.0026930635794997215, -0.002298035193234682, -0.0017458717338740826, -0.0010703919688239694, -0.00031429564114660025, 0.0004741043958347291, 0.0012445285683497787, 0.0019484779331833124, 0.0025428037624806166, 0.002992835594341159, 0.0032748389057815075, 0.0033776313066482544, 0.0033032442443072796, 0.0030665933154523373, 0.002694194670766592, 0.0022220350801944733, 0.001692760968580842, 0.0011524091241881251, 0.0006469225627370179, 0.00021871825447306037, -9.644226520322263e-05, -0.0002720473275985569, -0.0002927093009930104, -0.0001551864406792447, 0.00013151293387636542, 0.0005469415918923914, 0.0010608683805912733, 0.0016356443520635366, 0.002229094970971346, 0.002797718159854412, 0.003299945266917348, 0.003699220484122634, 0.003966675605624914, 0.004083199426531792, 0.00404075812548399, 0.0038428776897490025, 0.0035042590461671352, 0.0030495633836835623, 0.0025114750023931265, 0.0019281817367300391, 0.0013404787750914693, 0.000788709323387593, 0.0003097737208008766, -6.557149026775733e-05, -0.00031492504058405757, -0.00042580548324622214, -0.00039645779179409146, -0.00023585089365951717, 3.7124780646990985e-05, 0.0003951916005462408, 0.0008048282470554113, 0.0012288561556488276, 0.0016292707296088338, 0.0019701048731803894, 0.0022201091051101685, 0.0023550516925752163, 0.0023594715166836977, 0.002227756194770336, 0.0019644773565232754, 0.001583958393894136, 0.0011091220658272505, 0.0005697082378901541, -3.968857246782505e-18, -0.0005637642461806536, -0.0010860988404601812, -0.0015348942251875997, -0.001883762190118432, -0.002113929484039545, -0.0022155456244945526, -0.0021883100271224976, -0.002041381783783436, -0.001792584778741002, -0.0014669756637886167, -0.0010948857525363564, -0.0007095901528373361, -0.0003447840572334826, -3.205064422218129e-05, 0.00020148465409874916, 0.00033514376264065504, 0.00035618292167782784, 0.00026067206636071205, 5.370632788981311e-05, -0.0002510589256417006, -0.0006325081922113895, -0.0010637129889801145, -0.001513996976427734, -0.0019512613071128726, -0.002344394102692604, -0.00266558350995183, -0.0028923603240400553, -0.0030092266388237476, -0.003008743282407522, -0.0028920115437358618, -0.0026685064658522606, -0.002355295931920409, -0.001975691644474864, -0.0015574562130495906, -0.0011306904489174485, -0.0007255699019879103, -0.00037009804509580135, -8.804354001767933e-05, 0.00010278524860041216, 0.0001918034249683842, 0.0001763606705935672, 6.185238453326747e-05, -0.00013877150195185095, -0.0004060578066855669, -0.0007155772764235735, -0.0010398091981187463, -0.001350239384919405, -0.0016195118660107255, -0.0018234759336337447, -0.0019429716048762202, -0.0019652280025184155, -0.0018847702303901315, -0.0017037733923643827, -0.001431841286830604, -0.0010852329432964325, -0.0006855986430309713, -0.00025832635583356023, 0.00016937701730057597, 0.0005705216317437589, 0.0009203355293720961, 0.0011980816489085555, 0.0013885560911148787, 0.0014831596054136753, 0.0014804658712819219, 0.001386249321512878, 0.0012129745446145535, 0.0009787911549210548, 0.0007061135256662965, 0.00041989603778347373, 0.00014573441876564175, -9.206277900375426e-05, -0.0002722879871726036, -0.00037839970900677145, -0.0003997239109594375, -0.0003322054399177432, -0.00017865751578938216, 5.1504961447790265e-05, 0.0003430235665291548, 0.0006759846583008766, 0.001027345540933311, 0.0013726806500926614, 0.0016880163457244635, 0.0019516156753525138, 0.002145579783245921, 0.002257149899378419, 0.0022796117700636387, 0.0022127442061901093, 0.0020627763587981462, 0.0018418632680550218, 0.001567126833833754, 0.0012593334540724754, 0.0009413105435669422, 0.0006362261483445764, 0.00036585761699825525, 0.00014898112567607313, 2.6941533112745066e-18, -7.208679744508117e-05, -6.43029052298516e-05, 2.014351775869727e-05, 0.0001721620064927265, 0.0003775192308239639, 0.0006179568590596318, 0.0008726002997718751, 0.0011195510160177946, 0.0013375411508604884, 0.0015075273113325238, 0.0016141030937433243, 0.001646628137677908, 0.0015999908791854978, 0.0014749517431482673, 0.001278043957427144, 0.0010210443288087845, 0.0007200569962151349, 0.00039428132004104555, 6.45600666757673e-05, -0.0002481828269083053, -0.0005244966014288366, -0.0007478339830413461, -0.0009057524148374796, -0.0009907972998917103, -0.001001005177386105, -0.0009399917908012867, -0.0008166226325556636, -0.0006442948943004012, -0.00043988513061776757, -0.00022244901629164815, -1.1767918294935953e-05, 0.00017314482829533517, 0.00031546695390716195, 0.0004018136241938919, 0.00042321564978919923, 0.0003757584490813315, 0.000260837230598554, 8.501256525050849e-05, -0.0001405193324899301, -0.0004007987445220351, -0.0006782486452721059, -0.0009540071478113532, -0.001209345064125955, -0.0014270605752244592, -0.001592749380506575, -0.0016958540072664618, -0.0017304178327322006, -0.0016954878810793161, -0.0015951412497088313, -0.0014381357468664646, -0.001237213728018105, -0.0010081147775053978, -0.0007683733128942549, -0.0005359933129511774, -0.00032809912227094173, -0.0001596649963175878, -4.241657006787136e-05, 1.6014655557228252e-05, 1.2623094335140195e-05, -5.079020047560334e-05, -0.0001677981053944677, -0.00032787275267764926, -0.0005172131932340562, -0.0007198111852630973, -0.000918672711122781, -0.0010971034644171596, -0.001239960198290646, -0.001334776752628386, -0.001372679602354765, -0.0013490266865119338, -0.0012637254549190402, -0.0011212077224627137, -0.0009300668025389314, -0.0007023857324384153, -0.00045281247003003955, -0.00019744950986932963, 4.7354409616673365e-05, 0.00026622108998708427, 0.0004458762414287776, 0.0005761156789958477, 0.0006505335331894457, 0.0006669608410447836, 0.0006275824271142483, 0.0005387280252762139, 0.00041035524918697774, 0.00025526591343805194, 8.811630686977878e-05, -7.570237357867882e-05, -0.0002212285326095298, -0.0003350524348206818, -0.00040631258161738515, -0.0004274924867786467, -0.00039496031240560114, -0.00030921297729946673, -0.00017480948008596897, 8.831717444337061e-19, 0.00020391734142322093, 0.00042346285772509873, 0.0006439975113607943, 0.000850823475047946, 0.0010302795562893152, 0.0011707505909726024, 0.0012635146267712116, 0.001303367898799479, 0.0012889798963442445, 0.0012229590211063623, 0.0011116195237264037, 0.0009644774254411459, 0.0007935093017295003, 0.0006122353370301425, 0.00043469376396387815, 0.0002743872464634478, 0.000143277837196365, 5.09067831444554e-05, 3.702923322634888e-06, 4.530474598141154e-06, 5.250755566521548e-05, 0.00014310679398477077, 0.00026852800510823727, 0.0004183128767181188, 0.0005801531951874495, 0.0007408307865262032, 0.0008872179896570742, 0.0010072625009343028, 0.0010908835101872683, 0.0011307138483971357, 0.0011226311326026917, 0.0010660437401384115, 0.000963909609708935, 0.0008224890916608274, 0.0006508539663627744, 0.000460190640296787, 0.0002629501686897129, 7.191288750618696e-05, -0.00010076465696329251, -0.00024444726295769215, -0.0003507970250211656, -0.00041437073377892375, -0.00043299535172991455, -0.0004078962665516883, -0.0003435692342463881, -0.0002474099164828658, -0.00012912903912365437, -3.585707497240672e-19, 0.00012800410331692547, 0.00024311791639775038, 0.000334667885908857, 0.0003938667068723589, 0.00041445993701927364, 0.00039317685877904296, 0.00032995472429320216, 0.0002279202890349552, 9.31333561311476e-05, -6.588744872715324e-05, -0.0002388186112511903, -0.00041431537829339504, -0.0005808650166727602, -0.0007276453543454409, -0.0008453248883597553, -0.0009267440182156861, -0.0009674285538494587, -0.0009658979251980782, -0.0009237474878318608, -0.0008454996859654784, -0.000738238450139761, -0.0006110551184974611, -0.0004743497120216489, -0.00033904032898135483, -0.00021574132551904768, -0.00011397171329008415, -4.145253842580132e-05, -3.5453977034194395e-06, -2.8724823550874135e-06, -3.914525223081e-05, -0.00010921256034635007, -0.00020732272241730243, -0.000325578119372949, -0.0004545464471448213, -0.0005839817458763719, -0.000703600060660392, -0.0008038514642976224, -0.0008766305400058627, -0.0009158727480098605, -0.0009179930784739554, -0.000882135471329093, -0.0008102164138108492, -0.000706760969478637, -0.0005785445682704449, -0.00043407068005762994, -0.0002829238655976951, -0.00013504714297596365, -2.582592082444939e-18, 0.00011374888708814979, 0.0001994407211896032, 0.00025251219631172717, 0.0002709125983528793, 0.00025522991199977696, 0.0002086188760586083, 0.00013653698260895908, 4.631117917597294e-05, -5.343164229998365e-05, -0.00015342628466896713, -0.0002444727288093418, -0.0003181281790602952, -0.00036733667366206646, -0.0003869487263727933, -0.0003740942047443241, -0.000328380789142102, -0.00025190567248500884, -0.00014908025332260877, -2.6283949409844354e-05, 0.00010862691851798445, 0.0002469161117915064, 0.0003796251257881522, 0.0004982416867278516, 0.0005953291547484696, 0.0006650699069723487, 0.0007036829483695328, 0.0007096855551935732, 0.0006839811103418469, 0.0006297673680819571, 0.0005522748688235879, 0.00045835517812520266, 0.00035595224471762776, 0.0002534970117267221, 0.00015927103231661022, 8.078764949459583e-05, 2.423608566459734e-05, -5.969956418994116e-06, -7.5066095632791985e-06, 1.9705195882124826e-05, 7.351431850111112e-05, 0.0001497208868386224, 0.00024240957282017916, 0.0003444083849899471, 0.00044783749035559595, 0.0005447060102596879, 0.0006275122868828475, 0.00068980164360255, 0.0007266419124789536, 0.0007349794614128768, 0.0007138532819226384, 0.000664449529722333, 0.0005899956449866295, 0.0004955028998665512, 0.0003873779496643692, 0.00027293365565128624, 0.00015983691264409572, 5.553503433475271e-05, -3.329598985146731e-05, -0.00010124038817593828, -0.00014453264884650707, -0.00016132043674588203, -0.00015178199100773782, -0.00011809048010036349, -6.422933074645698e-05, 4.325972895458108e-06, 8.103494474198669e-05, 0.00015879474813118577, 0.00023048033472150564, 0.0002894811623264104, 0.00033019448164850473, 0.00034843856701627374, 0.00034175600740127265, 0.0003095846332143992, 0.00025328577612526715, 0.00017602772277314216, 8.253537089331076e-05, -2.127450170519296e-05, -0.00012874361709691584, -0.00023297398001886904, -0.0003273431211709976, -0.0004059937782585621, -0.0004642622370738536, -0.000499012996442616, -0.000508856785017997, -0.0004942353698424995, -0.0004573693440761417, -0.0004020732012577355, -0.000333453033817932, -0.00025751092471182346, -0.00018068608187604696, -0.00010936755279544741, -4.9415833927923813e-05, -5.728490577894263e-06, 1.8117911167792045e-05, 2.0123445210629143e-05, 4.064368741885494e-19, -4.0823055314831436e-05, -9.932186367223039e-05, -0.00017111931811086833, -0.0002508255129214376, -0.00033245052327401936, -0.0004098587960470468, -0.00047722976887598634, -0.0005294909351505339, -0.0005626911879517138, -0.0005742861540056765, -0.0005633165710605681, -0.0005304660880938172, -0.000477995810797438, -0.000409561675041914, -0.00032992937485687435, -0.0002446091384626925, -0.00015943868493195623, -8.014516060939059e-05, -1.1920506949536502e-05, 4.095953772775829e-05, 7.544393884018064e-05, 8.992021321319044e-05, 8.431856986135244e-05, 6.009963544784114e-05, 2.0127688912907615e-05, -3.1559786293655634e-05, -9.006814798340201e-05, -0.00015002272266428918, -0.0002059781108982861, -0.00025282881688326597, -0.00028619071235880256, -0.0003027241909876466, -0.00030037687974981964, -0.00027852688799612224, -0.00023801835777703673, -0.00018108633230440319, -0.00011117885151179507, -3.268964428571053e-05, 4.937703852192499e-05, 0.00012978422455489635, 0.00020345367374829948, 0.00026584166334941983, 0.00031327109900303185, 0.0003431958903092891, 0.00035437781480140984, 0.0003469642251729965, 0.000322461302857846, 0.00028360620490275323, 0.00023414820316247642, 0.0001785569911589846, 0.00012167946988483891, 6.837237015133724e-05, 2.3137663447414525e-05, -1.0211662811343558e-05, -2.8830803785240278e-05, -3.104707138845697e-05, -1.6473983123432845e-05, 1.3972140550322365e-05, 5.815325494040735e-05, 0.0001128813746618107, 0.00017416727496311069, 0.0002375266922172159, 0.0002983206941280514, 0.0003521041653584689, 0.00039495647069998085, 0.000423769757617265, 0.00043647337588481605, 0.0004321791639085859, 0.00041123604751192033, 0.00037519275792874396, 0.00032667029881849885, 0.0002691563859116286, 0.0002067368186544627, 0.000143785189720802, 8.463420817861333e-05, 3.325360012240708e-05, -7.041494427539874e-06, -3.383009971003048e-05, -4.575560524244793e-05, -4.261452704668045e-05, -2.535810199333355e-05, 3.992569418187486e-06, 4.251053906045854e-05, 8.659312879899517e-05, 0.0001322402385994792, 0.00017535951337777078, 0.0002120753051713109, 0.00023901823442429304, 0.0002535738458391279, 0.00025407233624719083, 0.00023990565387066454, 0.0002115638490067795, 0.00017058908997569233, 0.00011945151345571503, 6.13565935054794e-05, -2.7772325402647653e-19, -6.071198367862962e-05, -0.00011695479770423844, -0.00016526876424904913, -0.00020281216711737216, -0.00022756530961487442, -0.00023847116972319782, -0.0002355025935685262, -0.0002196518616983667, -0.00019284414884168655, -0.00015778219676576555, -0.00011773466394515708, -7.62844574637711e-05, -3.705619747051969e-05, -3.4437225622241385e-06, 2.164230500056874e-05, 3.5987799492431805e-05, 3.82342332159169e-05, 2.7971873350907117e-05, 5.760933618148556e-06, -2.6920066375168972e-05, -6.779417890356854e-05, -0.00011396440822863951, -0.00016213661001529545, -0.00020886980928480625, -0.0002508348261471838, -0.00028506203670985997, -0.0003091593680437654, -0.00032148498576134443, -0.0003212622832506895, -0.0003086288343183696, -0.00028461628244258463, -0.0002510643098503351, -0.00021047471091151237, -0.0001658177498029545, -0.0001203057836391963, -7.715124229434878e-05, -3.932734398404136e-05, -9.349378160550259e-06, 1.0907290743489284e-05, 2.0339328330010176e-05, 1.8688288037083112e-05, 6.549456429638667e-06, -1.4683294466522057e-05, -4.2931798816425726e-05, -7.559780351584777e-05, -0.00010976435441989452, -0.000142418677569367, -0.00017067995213437825, -0.0001920145732583478, -0.00020442312234081328, -0.0002065853914245963, -0.00019795291882473975, -0.00017878285143524408, -0.0001501112274127081, -0.00011366826220182702, -7.17427465133369e-05, -2.700613549677655e-05, 1.7689993910607882e-05, 5.9527639677980915e-05, 9.593122376827523e-05, 0.0001247559703188017, 0.0001444419613108039, 0.00015412276843562722, 0.00015368104504887015, 0.00014374747115653008, 0.00012564392818603665, 0.0001012755892588757, 7.298075070139021e-05, 4.3349951738491654e-05, 1.5028518646431621e-05, -9.482860150455963e-06, -2.801425762299914e-05, -3.888579158228822e-05, -4.102833918295801e-05, -3.405714960535988e-05, -1.8293419998371974e-05, 5.267310370982159e-06, 3.503678090055473e-05, 6.895912520121783e-05, 0.00010466953972354531, 0.00013967427366878837, 0.00017153826775029302, 0.0001980662054847926, 0.00021746366110164672, 0.00022846661158837378, 0.00023042940301820636, 0.00022336610709317029, 0.00020794167357962579, 0.00018541482859291136, 0.0001575372734805569, 0.00012641726061701775, 9.435815445613116e-05, 6.36844415566884e-05, 3.6568206269294024e-05, 1.4869176084175706e-05, 4.759688234497502e-19, -7.17336661182344e-06, -6.38918436379754e-06, 1.9984447590104537e-06, 1.7054169802577235e-05, 3.733905396074988e-05, 6.102500992710702e-05, 8.603695459896699e-05, 0.00011021178215742111, 0.00013146201672498137, 0.00014793191803619266, 0.0001581342949066311, 0.0001610582257853821, 0.00015623995568603277, 0.00014379181084223092, 0.000124387996038422, 9.920832962961867e-05, 6.984508945606649e-05, 3.817994365817867e-05, 6.240906714083394e-06, -2.3949956812430173e-05, -5.0526530685601756e-05, -7.19151648809202e-05, -8.694765710970387e-05, -9.494254481978714e-05, -9.574909199727699e-05, -8.975099626695737e-05, -7.783022010698915e-05, -6.12939620623365e-05, -4.177083246759139e-05, -2.1084328182041645e-05, -1.1133173529742635e-06, 1.6349844372598454e-05, 2.9732904295087792e-05, 3.779915641644038e-05, 3.973634011344984e-05, 3.521261169225909e-05, 2.4395909349550493e-05, 7.935660505609121e-06, -1.3091317669022828e-05, -3.7266232538968325e-05, -6.293825572356582e-05, -8.835042535793036e-05, -0.00011177201668033376, -0.00013162723917048424, -0.00014661080786027014, -0.00015578184684272856, -0.00015862945292610675, -0.00015510529919993132, -0.00014562129217665642, -0.00013101288641337305, -0.00011247133807046339, -9.1450237960089e-05, -6.955358549021184e-05, -4.8414287448395044e-05, -2.957200922537595e-05, -1.4359578017320018e-05, -3.806434506259393e-06, 1.433989268662117e-06, 1.1278054898866685e-06, -4.527756118477555e-06, -1.492517640144797e-05, -2.9097900551278144e-05, -4.579779124469496e-05, -6.359260441968217e-05, -8.097604586509988e-05, -9.648183186072856e-05, -0.00010879342153202742, -0.00011684091441566125, -0.0001198785612359643, -0.00011753669241443276, -0.00010984512482536957, -9.722632239572704e-05, -8.04592709755525e-05, -6.06172761763446e-05, -3.8984533603070304e-05, -1.6958128981059417e-05, 4.057182195538189e-06, 2.2753249140805565e-05, 3.801426646532491e-05, 4.8996804252965376e-05, 5.518843681784347e-05, 5.6440840126015246e-05, 5.2975257858633995e-05, 4.536025880952366e-05, 3.446387199801393e-05, 2.138402487616986e-05, 7.362746146100108e-06, -6.309201580734225e-06, -1.8390001059742644e-05, -2.7779446099884808e-05, -3.359971378813498e-05, -3.525840293150395e-05, -3.248933353461325e-05, -2.536837746447418e-05, -1.4303484022093471e-05, -3.86560602948301e-19, 1.6595782653894275e-05, 3.4370332286925986e-05, 5.212807809584774e-05, 6.868159107398242e-05, 8.293991413665935e-05, 9.398848487762734e-05, 0.00010115483746631071, 0.00010405515786260366, 0.00010261887655360624, 9.708934521768242e-05, 8.80012012203224e-05, 7.613624620717019e-05, 6.246151315281168e-05, 4.805449862033129e-05, 3.402110087336041e-05, 2.1412737623904832e-05, 1.11487124740961e-05, 3.949597612518119e-06, 2.8644902272390027e-07, 3.4943451510116574e-07, 4.037917278765235e-06, 1.0972444215440191e-05, 2.0527410015347414e-05, 3.188167465850711e-05, 4.408307358971797e-05, 5.612176755676046e-05, 6.70069275656715e-05, 7.584079867228866e-05, 8.188482752302662e-05, 8.461284596705809e-05, 8.374772005481645e-05, 7.927881233626977e-05, 7.14592169970274e-05, 6.078349906601943e-05, 4.794755659531802e-05, 3.3794156479416415e-05, 1.9248280295869336e-05, 5.247271019470645e-06, -7.328868832701119e-06, -1.7721862604958005e-05, -2.5349487259518355e-05, -2.984591446875129e-05, -3.108531382167712e-05, -2.918712198152207e-05, -2.4502976884832606e-05, -1.758645157678984e-05, -9.148187018581666e-06, -5.063597428853296e-20, 9.007720109366346e-06, 1.7050531823770143e-05, 2.3391512513626367e-05, 2.7435326046543196e-05, 2.8770880817319266e-05, 2.7199545002076775e-05, 2.2747004550183192e-05, 1.5658211850677617e-05, 6.37597986496985e-06, -4.494898803386604e-06, -1.623506614123471e-05, -2.806587508530356e-05, -3.9208243833854795e-05, -4.894063749816269e-05, -5.665184653480537e-05, -6.188475526869297e-05, -6.436786497943103e-05, -6.403253064490855e-05, -6.101471808506176e-05, -5.5641590734012425e-05, -4.8403879191027954e-05, -3.9916652895044535e-05, -3.087131699430756e-05, -2.1982814359944314e-05, -1.3935844435764011e-05, -7.334280326176668e-06, -2.6574471121421084e-06, -2.264248024630433e-07, -1.8274870683399058e-07, -2.480883495081798e-06, -6.8948133957746904e-06, -1.3038024917477742e-05, -2.0395171304699033e-05, -2.8362848752294667e-05, -3.62963110092096e-05, -4.355849523562938e-05, -4.9567690439289436e-05, -5.384029645938426e-05, -5.602551391348243e-05, -5.592962770606391e-05, -5.3528070566244423e-05, -4.896469181403518e-05, -4.253848237567581e-05, -3.467890928732231e-05, -2.591194788692519e-05, -1.681944922893308e-05, -7.995062333066016e-06, -4.971666966643111e-20, 6.6780053202819545e-06, 1.1659562005661428e-05, 1.4699785424454603e-05, 1.570396671013441e-05, 1.4731761439179536e-05, 1.1989768609055318e-05, 7.813269803591538e-06, 2.6386685476609273e-06, -3.0311339287436567e-06, -8.665725545142777e-06, -1.3747543562203646e-05, -1.781055107130669e-05, -2.047438101726584e-05, -2.147148370568175e-05, -2.0665334886871278e-05, -1.805854481062852e-05, -1.3790404409519397e-05, -8.124261512421072e-06, -1.4258359897212358e-06, 5.865727871423587e-06, 1.3271796888147946e-05, 2.0310537365730852e-05, 2.653278897923883e-05, 3.155487866024487e-05, 3.508594454615377e-05, 3.6947876651538536e-05, 3.708642179844901e-05, 3.557290619937703e-05, 3.2596544770058244e-05, 2.844804839696735e-05, 2.3496044377679937e-05, 1.81580562639283e-05, 1.2868410522060003e-05, 8.045493814279325e-06, 4.060822448082035e-06, 1.212198981193069e-06, -2.9710781745961867e-07, -3.7171261624280305e-07, 9.708536481412011e-07, 3.603656296036206e-06, 7.301986443053465e-06, 1.1762086614908185e-05, 1.6625428543193266e-05, 2.1506642951862887e-05, 2.60229116975097e-05, 2.982261503348127e-05, 3.2611129427095875e-05, 3.4171829611295834e-05, 3.438090061536059e-05, 3.321492476970889e-05, 3.075079439440742e-05, 2.715819573495537e-05, 2.2685258954879828e-05, 1.7638651115703396e-05, 1.2359699212538544e-05, 7.198394541774178e-06, 2.48725586970977e-06, -1.4829527117399266e-06, -4.483922566578258e-06, -6.365404260577634e-06, -7.064671535772504e-06, -6.609247520827921e-06, -5.112840426590992e-06, -2.764920964182238e-06, 1.8514899124966178e-07, 3.448134521022439e-06, 6.717510132148163e-06, 9.692865205579437e-06, 1.2102372238587122e-05, 1.3722634321311489e-05, 1.439450807083631e-05, 1.4033787010703236e-05, 1.2636052815651055e-05, 1.0275458407704718e-05, 7.097652542142896e-06, 3.307513679828844e-06, -8.47292596972693e-07, -5.095614142192062e-06, -9.163457434624434e-06, -1.2794411304639652e-05, -1.576832619321067e-05, -1.7916880096890964e-05, -1.913494816108141e-05, -1.9387009160709567e-05, -1.8708204152062535e-05, -1.720011823636014e-05, -1.5021676517790183e-05, -1.237597916770028e-05, -9.494119694863912e-06, -6.617289272980997e-06, -3.978527729486814e-06, -1.7855024907476036e-06, -2.0557799018661171e-07, 6.457555059569131e-07, 7.123069849512831e-07, 8.215078337615332e-20, -1.425026880497171e-06, -3.442784645812935e-06, -5.8896825976262335e-06, -8.5718083937536e-06, -1.128017083829036e-05, -1.38067189254798e-05, -1.5959922166075557e-05, -1.757875179464463e-05, -1.8544056729297154e-05, -1.8786538930726238e-05, -1.829082248150371e-05, -1.7095377188525163e-05, -1.5288447684724815e-05, -1.3000330909562763e-05, -1.0392719559604302e-05, -7.645944606338162e-06, -4.945143246004591e-06, -2.466412524881889e-06, -3.639673877842142e-07, 1.2407316489770892e-06, 2.267136324007879e-06, 2.6805023480847012e-06, 2.493231022526743e-06, 1.762649276315642e-06, 5.854863616150396e-07, -9.104568903239851e-07, -2.5767512852326035e-06, -4.25605367126991e-06, -5.794186108687427e-06, -7.051662578305695e-06, -7.913810804893728e-06, -8.298771717818454e-06, -8.162829544744454e-06, -7.502730113628786e-06, -6.3549282458552625e-06, -4.7918524614942726e-06, -2.915590812335722e-06, -8.495126166963018e-07, 1.2714757531284704e-06, 3.3112808068835875e-06, 5.142777808941901e-06, 6.657021003775299e-06, 7.770840056764428e-06, 8.432297363469843e-06, 8.62365686771227e-06, 8.36170875118114e-06, 7.695504791627172e-06, 6.7017367655353155e-06, 5.478191269503441e-06, 4.1358016460435465e-06, 2.789958898574696e-06, 1.551741092953307e-06, 5.197276777835214e-07, -2.2700196211644652e-07, -6.341982157209713e-07, -6.757429673598381e-07, -3.547388871538715e-07, 2.976310611302324e-07, 1.2253200338818715e-06, 2.352405545025249e-06, 3.589418611227302e-06, 4.84049814986065e-06, 6.01080273554544e-06, 7.0136188696778845e-06, 7.776633538014721e-06, 8.246925062849186e-06, 8.394348697038367e-06, 8.21308458398562e-06, 7.721328984189313e-06, 6.959172424103599e-06, 5.98491214987007e-06, 4.870114480581833e-06, 3.6938463381375186e-06, 2.536532065278152e-06, 1.4739226799065364e-06, 5.716180453418929e-07, -1.194551799699184e-07, -5.663034130520828e-07, -7.556611762993271e-07, -6.942357799744059e-07, -4.074368575857079e-07, 6.325814183583134e-08, 6.640565288762446e-07, 1.333393925051496e-06, 2.0068987396371085e-06, 2.622382453409955e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_2_3</value></param>
<param><key>value</key><value>[-1.3427033991320059e-06, -2.23805022869783e-06, -3.12073962049908e-06, -3.9077708606782835e-06, -4.521584742178675e-06, -4.8975130084727425e-06, -4.990310571884038e-06, -4.779114988195943e-06, -4.270321824151324e-06, -3.4980116652150173e-06, -2.521813939893036e-06, -1.4223023754311725e-06, -2.942677497230761e-07, 7.615768140567525e-07, 1.647745079935703e-06, 2.2791518858866766e-06, 2.5914587240549736e-06, 2.5477820599917322e-06, 2.14308033719135e-06, 1.4057347925700014e-06, 3.9607505186722847e-07, -7.9811326259005e-07, -2.0687832602561684e-06, -3.296945124020567e-06, -4.363313109934097e-06, -5.159329248272115e-06, -5.597560630121734e-06, -5.6204771681223065e-06, -5.206741661822889e-06, -4.374350737634813e-06, -3.1802364901523106e-06, -1.7162476524390513e-06, -1.0177357268048581e-07, 1.526411665508931e-06, 3.0262312975537498e-06, 4.263251867087092e-06, 5.123323717270978e-06, 5.523731488210615e-06, 5.421784408099484e-06, 4.819963578484021e-06, 3.767059524761862e-06, 2.3550635432911804e-06, 7.119813858480484e-07, -1.008888261821994e-06, -2.642325398483081e-06, -4.0260492824018e-06, -5.01574049849296e-06, -5.49883861822309e-06, -5.405817319115158e-06, -4.717804131360026e-06, -3.469760713414871e-06, -1.748790850797377e-06, 3.1240253406394913e-07, 2.5464371447014855e-06, 4.765669473272283e-06, 6.778876922908239e-06, 8.40872417029459e-06, 9.508433322480414e-06, 9.976094588637352e-06, 9.765241884451825e-06, 8.890609024092555e-06, 7.428423032251885e-06, 5.511041763384128e-06, 3.3162962154165143e-06, 1.0523798437134246e-06, -1.0604628641885938e-06, -2.8098238544771448e-06, -4.010820248367963e-06, -4.523765255726175e-06, -4.268148131814087e-06, -3.2315354019374354e-06, -1.4724533912158222e-06, 8.831636932882247e-07, 3.6518088109005475e-06, 6.607760951737873e-06, 9.502701686869841e-06, 1.2087900358892512e-05, 1.4136979189061094e-05, 1.546720159240067e-05, 1.5957275536493398e-05, 1.5559957319055684e-05, 1.4308200661616866e-05, 1.2314062587392982e-05, 9.760372449818533e-06, 6.885694801894715e-06, 3.963827111874707e-06, 1.2795828752132365e-06, -8.970121712081891e-07, -2.335785211471375e-06, -2.8684185053862166e-06, -2.405310624453705e-06, -9.456205702917941e-07, 1.4205753586793435e-06, 4.5184015107224695e-06, 8.10220171842957e-06, 1.187636280519655e-05, 1.5521185559919104e-05, 1.8721548258326948e-05, 2.119581404258497e-05, 2.2722317225998268e-05, 2.3160977434599772e-05, 2.2467922462965362e-05, 2.070166010526009e-05, 1.8020000425167382e-05, 1.4667851246485952e-05, 1.0956759979308117e-05, 7.237927093228791e-06, 3.870990894938586e-06, 1.1913505204574903e-06, -5.209981850384793e-07, -1.0682515494409017e-06, -3.5465379255583684e-07, 1.6025414879550226e-06, 4.672200248023728e-06, 8.618821993877646e-06, 1.3121795745973941e-05, 1.7802831280278042e-05, 2.225926255050581e-05, 2.610025512694847e-05, 2.8982729418203235e-05, 3.064364500460215e-05, 3.092568658757955e-05, 2.979380587930791e-05, 2.7340962333255447e-05, 2.378226963628549e-05, 1.9437922674114816e-05, 1.470611368858954e-05, 1.0028312317444943e-05, 5.8498894759395625e-06, 2.5795425244723447e-06, 5.512821985576011e-07, -7.560434056586018e-09, 1.0007673836298636e-06, 3.5329023830854567e-06, 7.405470569210593e-06, 1.230898760695709e-05, 1.783354309736751e-05, 2.3504155251430348e-05, 2.8822760214097798e-05, 3.331315019750036e-05, 3.656479384517297e-05, 3.8271518860710785e-05, 3.826146348728798e-05, 3.651533916126937e-05, 3.317116352263838e-05, 2.8514712539617904e-05, 2.295633385074325e-05, 1.6995962141663767e-05, 1.1179269677086268e-05, 6.0488296185212675e-06, 2.0946104086760897e-06, -2.9166966442062403e-07, -8.541096008229943e-07, 5.014769612898817e-07, 3.695910891110543e-06, 8.480575161229353e-06, 1.4456856661126949e-05, 2.1109623048687354e-05, 2.7851936465594918e-05, 3.407715121284127e-05, 3.921376992366277e-05, 4.277812331565656e-05, 4.4420023186830804e-05, 4.395708310767077e-05, 4.1394403524463996e-05, 3.6927525798091665e-05, 3.092813494731672e-05, 2.3913382392493077e-05, 1.650148260523565e-05, 9.357248927699402e-06, 3.1324211704486515e-06, -1.5939012882881798e-06, -4.369277576188324e-06, -4.911387804895639e-06, -3.1367799238068983e-06, 8.279725989268627e-07, 6.654040134890238e-06, 1.3836650396115147e-05, 2.1737896531703882e-05, 2.9642400477314368e-05, 3.682104215840809e-05, 4.259702473063953e-05, 4.6408367779804394e-05, 4.786100907949731e-05, 4.676759635913186e-05, 4.316811464377679e-05, 3.733015910256654e-05, 2.972856418637093e-05, 2.100576057273429e-05, 1.1916238690901082e-05, 3.2598416055407142e-06, -4.1902058001141995e-06, -9.758076885191258e-06, -1.2928469004691578e-05, -1.3396202120929956e-05, -1.1097540664195549e-05, -6.2200851971283555e-06, 8.100366812868742e-07, 9.362889613839798e-06, 1.8658573026186787e-05, 2.7835611035698093e-05, 3.602789729484357e-05, 4.24433674197644e-05, 4.64372023998294e-05, 4.757293936563656e-05, 4.5665543439099565e-05, 4.080240978510119e-05, 3.333992208354175e-05, 2.3875447368482128e-05, 1.3197029147704598e-05, 2.2148660718812607e-06, -8.119410267681815e-06, -1.689855162112508e-05, -2.3342865461017936e-05, -2.687313281057868e-05, -2.7166512154508382e-05, -2.4189990654122084e-05, -1.820807665353641e-05, -9.763532034412492e-06, 3.674749962101487e-07, 1.1242164873692673e-05, 2.1834146537003107e-05, 3.1125346140470356e-05, 3.8198639231268317e-05, 4.2322775698266923e-05, 4.302177330828272e-05, 4.01221914216876e-05, 3.377365646883845e-05, 2.4440359993604943e-05, 1.2863850315625314e-05, -1.154525449249583e-18, -1.306444846704835e-05, -2.520855014154222e-05, -3.537843804224394e-05, -4.2684070649556816e-05, -4.6482593461405486e-05, -4.644056025426835e-05, -4.256894317222759e-05, -3.5227465559728444e-05, -2.5097258912865072e-05, -1.3123918506607879e-05, -4.3567803231781e-07, 1.175628221972147e-05, 2.2266560335992835e-05, 3.0043587685213424e-05, 3.426715556997806e-05, 3.44264080922585e-05, 3.0370925742317922e-05, 2.2329815692501143e-05, 1.0896656931436155e-05, -3.0189148674253374e-06, -1.8269038264406845e-05, -3.3568256185390055e-05, -4.7608144086552784e-05, -5.917573798797093e-05, -6.726505671394989e-05, -7.117145287338644e-05, -7.0560046879109e-05, -6.550156103912741e-05, -5.647184661938809e-05, -4.431464185472578e-05, -3.0170369427651167e-05, -1.537695061415434e-05, -1.3512187706510304e-06, 1.0538541573623661e-05, 1.9097511540167034e-05, 2.3415330360876396e-05, 2.2952870494918898e-05, 1.7596585166756995e-05, 7.674970220250543e-06, -6.064823537599295e-06, -2.251874866487924e-05, -4.032088691019453e-05, -5.796361801913008e-05, -7.393238774966449e-05, -8.684297790750861e-05, -9.556899749441072e-05, -9.934768604580313e-05, -9.785428846953437e-05, -9.12377072381787e-05, -8.011365571292117e-05, -6.551537808263674e-05, -4.8805730330059305e-05, -3.15581783070229e-05, -1.541693927720189e-05, -1.948789531525108e-06, 7.500213996536331e-06, 1.1929958418477327e-05, 1.0781870514620095e-05, 3.995769020548323e-06, -7.977710993145593e-06, -2.4210876290453598e-05, -4.337649079388939e-05, -6.386260793078691e-05, -8.39148269733414e-05, -0.00010179344826610759, -0.00011593141971388832, -0.00012507883366197348, -0.00012842063733842224, -0.00012565632641781121, -0.00011703440395649523, -0.00010333715181332082, -8.58168859849684e-05, -6.608883268199861e-05, -4.5989414502400905e-05, -2.7412706913310103e-05, -1.2139395948906895e-05, -1.6737170653868816e-06, 2.8967210710106883e-06, 1.0052012839878444e-06, -7.3356818575121e-06, -2.1527368517126888e-05, -4.043173248646781e-05, -6.246707198442891e-05, -8.574556704843417e-05, -0.00010824033233802766, -0.0001279673888348043, -0.00014316602027975023, -0.0001524613908259198, -0.0001549942244309932, -0.00015050548245199025, -0.00013936776667833328, -0.00012255972251296043, -0.00010158524673897773, -7.834402640582994e-05, -5.49643809790723e-05, -3.3613290725043043e-05, -1.6300396964652464e-05, -4.693715254688868e-06, 3.6045939566520246e-08, -2.6718914796219906e-06, -1.2709603652183432e-05, -2.9301572794793174e-05, -5.106633034301922e-05, -7.613384514115751e-05, -0.00010230873886030167, -0.00012726504064630717, -0.00014875536726322025, -0.00016481555940117687, -0.0001739463332341984, -0.00017525505973026156, -0.00016854441491886973, -0.0001543389807920903, -0.00013384694466367364, -0.00010885907977353781, -8.159397111739963e-05, -5.450211756397039e-05, -3.0046867323108017e-05, -1.0481203389645088e-05, 2.3590787350258324e-06, 7.227024525491288e-06, 3.584946398405009e-06, -8.337940926139709e-06, -2.7556679924600758e-05, -5.2410374337341636e-05, -8.070425246842206e-05, -0.00010990190639859065, -0.00013735084212385118, -0.00016052142018452287, -0.00017723756900522858, -0.0001858782779891044, -0.0001855314039858058, -0.0001760849409038201, -0.00015824708680156618, -0.000133492038003169, -0.00010393584670964628, -7.21525211702101e-05, -4.094634277862497e-05, -1.3100625437800772e-05, 8.87478563527111e-06, 2.2974245439399965e-05, 2.7884190785698593e-05, 2.3110545953386463e-05, 9.033461537910625e-06, -1.3116551599523518e-05, -4.1359806346008554e-05, -7.313774403883144e-05, -0.00010553775791777298, -0.00013555274927057326, -0.00016035250155255198, -0.00017754205327946693, -0.00018538405129220337, -0.00018296382040716708, -0.00017028216097969562, -0.00014826613187324256, -0.00011869613081216812, -8.405475091421977e-05, -4.731022272608243e-05, -1.1653270121314563e-05, 1.978922591661103e-05, 4.42382697656285e-05, 5.951855564489961e-05, 6.426264008041471e-05, 5.8044308389071375e-05, 4.142820762353949e-05, 1.5930381778161973e-05, -1.6107947885757312e-05, -5.172277087694965e-05, -8.758847252465785e-05, -0.00012031484948238358, -0.0001467534457333386, -0.00016428546223323792, -0.00017106524319387972, -0.00016619627422187477, -0.00014982355060055852, -0.00012313239858485758, -8.82531821844168e-05, -4.807940058526583e-05, -6.014348855387652e-06, 3.433116580708884e-05, 6.946341454749927e-05, 9.63234415394254e-05, 0.00011256911238888279, 0.0001167952868854627, 0.00010867184028029442, 8.898576925275847e-05, 5.958261317573488e-05, 2.321137799299322e-05, -1.671416248427704e-05, -5.6417098676320165e-05, -9.209529525833204e-05, -0.00012026543845422566, -0.00013808207586407661, -0.00014360259228851646, -0.0001359732123091817, -0.00011551872739801183, -8.372631418751553e-05, -4.312403325457126e-05, 2.936369355666102e-06, 5.057366797700524e-05, 9.572259295964614e-05, 0.00013449981634039432, 0.0001635575172258541, 0.00018039240967482328, 0.00018358175293542445, 0.00017292411939706653, 0.00014947113231755793, 0.00011544608423719183, 7.405558426398784e-05, 2.9210070351837203e-05, -1.482251627749065e-05, -5.379924550652504e-05, -8.388663991354406e-05, -0.00010201230179518461, -0.00010615149221848696, -9.552198025630787e-05, -7.066860416671261e-05, -3.342843410791829e-05, 1.3221219887782354e-05, 6.541986658703536e-05, 0.00011876358621520922, 0.00016869770479388535, 0.0002109273918904364, 0.00024180917534977198, 0.0002586877380963415, 0.0002601469459477812, 0.0002461514377500862, 0.00021806448057759553, 0.00017853983445093036, 0.0001312951644649729, 8.078711107373238e-05, 3.18155980494339e-05, -1.0906911484198645e-05, -4.318306309869513e-05, -6.171609129523858e-05, -6.441795994760469e-05, -5.0611368351383135e-05, -2.1106228814460337e-05, 2.1857722458662465e-05, 7.479827763745561e-05, 0.00013329264766070992, 0.00019236763182561845, 0.0002469438186381012, 0.00029229410574771464, 0.00032447517151013017, 0.00034069246612489223, 0.00033956533297896385, 0.00032126670703291893, 0.0002875237842090428, 0.00024147793010342866, 0.0001874152512755245, 0.00013039057375863194, 7.577796350233257e-05, 2.878765735658817e-05, -6.007293904986e-06, -2.5091607312788256e-05, -2.6337054805480875e-05, -9.209626114170533e-06, 2.5165438273688778e-05, 7.408810051856562e-05, 0.0001335113774985075, 0.00019839350716210902, 0.00026314370916225016, 0.0003221223596483469, 0.0003701507521327585, 0.0004029842675663531, 0.00041770620737224817, 0.0004130051238462329, 0.0003893100656569004, 0.00034876956488005817, 0.00029507477302104235, 0.00023314125428441912, 0.00016867661906871945, 0.000107672116428148, 5.586338011198677e-05, 1.8208704204880632e-05, -1.567642698319105e-06, -1.3250649999463349e-06, 1.9283435904071666e-05, 5.876150680705905e-05, 0.000113885966129601, 0.0001799808524083346, 0.0002513255749363452, 0.00032166182063519955, 0.00038475438486784697, 0.0004349552618805319, 0.0004677206161431968, 0.0004800328169949353, 0.00047068900312297046, 0.0004404278297442943, 0.0003918823495041579, 0.00032936051138676703, 0.00025847231154330075, 0.00018563521734904498, 0.00011750155681511387, 6.035899423295632e-05, 1.955791776708793e-05, -9.819989372772397e-07, 8.592020890318963e-07, 2.5191977329086512e-05, 7.00871751178056e-05, 0.00013173020852264017, 0.00020474726625252515, 0.00028267601737752557, 0.00035853913868777454, 0.00042547055636532605, 0.0004773373657371849, 0.000509302131831646, 0.000518272805493325, 0.0005032000481151044, 0.0004651917552109808, 0.0004074345051776618, 0.00033492551301606, 0.0002540381974540651, 0.0001719593274174258, 9.604676597518846e-05, 3.316560105304234e-05, -1.0937817933154292e-05, -3.2166582968784496e-05, -2.846001552825328e-05, 3.51210506973328e-18, 5.0783542974386364e-05, 0.00011941047705477104, 0.00019973571761511266, 0.0002844887494575232, 0.00036592036485671997, 0.00043649881263263524, 0.0004895931924693286, 0.0005200817831791937, 0.0005248301313258708, 0.0005029935273341835, 0.00045611560926772654, 0.0003880118892993778, 0.00030444629373960197, 0.0002126290200976655, 0.00012057791172992438, 3.640136128524318e-05, -3.2434378226753324e-05, -7.978652865858749e-05, -0.00010140412632608786, -9.533060801913962e-05, -6.210276478668675e-05, -4.726030056190211e-06, 7.157367508625612e-05, 0.00015980139141902328, 0.00025180887314490974, 0.0003390204510651529, 0.00041320465970784426, 0.0004672218346968293, 0.0004956803168170154, 0.0004954406758770347, 0.00046592095168307424, 0.0004091738082934171, 0.00032972556073218584, 0.00023419078206643462, 0.00013069348642602563, 2.8147018383606337e-05, -6.454461981775239e-05, -0.00013929196575190872, -0.00018955928680952638, -0.0002109702763846144, -0.00020172400400042534, -0.00016278207476716489, -9.780747495824471e-05, -1.2858749869337771e-05, 8.41354631120339e-05, 0.00018407592142466456, 0.00027750476147048175, 0.000355457334080711, 0.0004102776583749801, 0.00043632296728901565, 0.0004304929170757532, 0.00039253366412594914, 0.00032508763251826167, 0.00023348143440671265, 0.00012526949285529554, 9.571765986038372e-06, -0.00010373636905569583, -0.0002049098548013717, -0.0002852161996997893, -0.0003377344983164221, -0.00035799789475277066, -0.00034441996831446886, -0.00029846493271179497, -0.00022454325517173856, -0.00012963998597115278, -2.2706955860485323e-05, 8.612875535618514e-05, 0.00018646965327207, 0.00026858560158871114, 0.0003242998500354588, 0.00034774289815686643, 0.0003359043621458113, 0.00028893182752653956, 0.00021014634694438428, 0.00010577180364634842, -1.5601344784954563e-05, -0.000143770725117065, -0.0002678296295925975, -0.0003771465562749654, -0.0004623286076821387, -0.0005160822765901685, -0.000533891434315592, -0.0005144511233083904, -0.0004598147061187774, -0.00037523845094256103, -0.0002687354863155633, -0.00015037640696391463, -3.1397066777572036e-05, 7.68065729062073e-05, 0.00016370757657568902, 0.00022060779156163335, 0.0002414409682387486, 0.00022334537061396986, 0.00016695157682988793, 7.635740621481091e-05, -4.121094025322236e-05, -0.00017602372099645436, -0.0003167043614666909, -0.00045124307507649064, -0.0005680762114934623, -0.0006571360863745213, -0.0007107739802449942, -0.0007244734442792833, -0.0006972865667194128, -0.000631951552350074, -0.0005346784018911421, -0.00041461814544163644, -0.0002830623707268387, -0.00015244088717736304, -3.520865357131697e-05, 5.728051473852247e-05, 0.00011581026046769693, 0.00013415426656138152, 0.00010966602712869644, 4.355053897597827e-05, -5.9210084145888686e-05, -0.0001902728690765798, -0.0003386578755453229, -0.0004917170736007392, -0.0006362624117173254, -0.0007597528165206313, -0.0008514338987879455, -0.0009033253882080317, -0.0009109669481404126, -0.000873852870427072, -0.0007955125765874982, -0.000683227670378983, -0.0005474060890264809, -0.000400670018279925, -0.0002567333576735109, -0.00012917233107145876, -3.019636460521724e-05, 3.0467548640444875e-05, 4.647655805456452e-05, 1.5475459804292768e-05, -6.065480556571856e-05, -0.00017592939548194408, -0.0003207640256732702, -0.00048280894407071173, -0.0006480408483184874, -0.000802015361841768, -0.0009311680332757533, -0.0010240492410957813, -0.0010723762679845095, -0.0010718109551817179, -0.0010223854333162308, -0.0009285378619097173, -0.0007987504359334707, -0.0006448178901337087, -0.000480810267617926, -0.0003218212223146111, -0.00018261266814079136, -7.627718878211454e-05, -1.3039965779171325e-05, 6.90995648255921e-07, -3.7062196497572586e-05, -0.000123629390145652, -0.0002518925757613033, -0.0004108900320716202, -0.0005867729778401554, -0.000764031836297363, -0.0009268831927329302, -0.001060693641193211, -0.0011533125070855021, -0.0011961914133280516, -0.0011851887684315443, -0.0011209818767383695, -0.0010090488940477371, -0.0008592142257839441, -0.0006847998010925949, -0.0005014511989429593, -0.0003257431380916387, -0.00017369046690873802, -5.929505641688593e-05, 6.737295279890532e-06, 1.7993414076045156e-05, -2.7029924240196124e-05, -0.00012474702089093626, -0.0002667626249603927, -0.00044058854109607637, -0.0006307362345978618, -0.0008200904703699052, -0.0009914415422827005, -0.001129040028899908, -0.0012200322235003114, -0.0012556477449834347, -0.0012320271926000714, -0.0011506139999255538, -0.0010180700337514281, -0.000845719245262444, -0.0006485647754743695, -0.0004439649928826839, -0.0002500854607205838, -8.426392014371231e-05, 3.8563590351259336e-05, 0.00010723375453380868, 0.00011539776460267603, 6.213724554982036e-05, -4.7905406972859055e-05, -0.00020489799499046057, -0.00039466164889745414, -0.0005999144050292671, -0.0008018057560548186, -0.0009816066594794393, -0.0011224027257412672, -0.0012106394860893488, -0.0012373754289001226, -0.001199131365865469, -0.0010982519015669823, -0.0009427441982552409, -0.0007456046296283603, -0.0005236865836195648, -0.0002962122962344438, -8.305555093102157e-05, 9.704822150524706e-05, 0.00022820492449682206, 0.0002988229680340737, 0.0003026982885785401, 0.00023962203704286367, 0.00011545138841029257, -5.8366455050418153e-05, -0.0002657802833709866, -0.00048754524323157966, -0.0007029340486042202, -0.0008915972430258989, -0.0010354057885706425, -0.0011201082961633801, -0.0011366531252861023, -0.001082052243873477, -0.0009597031748853624, -0.0007791394600644708, -0.0005552216898649931, -0.0003068416262976825, -5.525041706277989e-05, 0.00017784084775485098, 0.0003722192195709795, 0.0005110091879032552, 0.0005822269013151526, 0.0005799052305519581, 0.000504686264321208, 0.0003638202615547925, 0.00017056857177522033, -5.694255742128007e-05, -0.00029731725226156414, -0.0005277951713651419, -0.0007262963335961103, -0.0008734228904359043, -0.0009542349143885076, -0.0009596408344805241, -0.0008872696780599654, -0.0007417449378408492, -0.0005343282828107476, -0.0002819604123942554, -5.7805614233075175e-06, 0.00027074673562310636, 0.0005239311722107232, 0.0007319952710531652, 0.0008770586573518813, 0.0009467880590818822, 0.0009355599759146571, 0.0008450277964584529, 0.0006840367568656802, 0.0004678868572227657, 0.0002170075022149831, -4.484363671508618e-05, -0.00029269844526425004, -0.0005026240833103657, -0.0006538952002301812, -0.0007308952626772225, -0.0007245731540024281, -0.0006333198398351669, -0.000463179312646389, -0.00022737124527338892, 5.48398784303572e-05, 0.0003598317562136799, 0.0006617195322178304, 0.0009346745209768414, 0.0011552581563591957, 0.0013045606901869178, 0.0013699502451345325, 0.0013462689239531755, 0.0012363661080598831, 0.0010509106796234846, 0.0008074972429312766, 0.0005291171255521476, 0.0002421289391350001, -2.6093835913343355e-05, -0.00024962754105217755, -0.0004063541709911078, -0.00047999448725022376, -0.0004616317164618522, -0.0003505836648400873, -0.00015453851665370166, 0.00011106407328043133, 0.00042435835348442197, 0.0007589699234813452, 0.0010863582137972116, 0.0013783748727291822, 0.0016098112100735307, 0.0017607011832296848, 0.0018181735649704933, 0.0017776768654584885, 0.0016434675781056285, 0.001428302493877709, 0.0011523640714585781, 0.0008415027987211943, 0.0005249526002444327, 0.00023271917598322034, -7.124535841285251e-06, -0.0001709932112134993, -0.00024196156300604343, -0.00021135489805601537, -7.960865332279354e-05, 0.00014368734264280647, 0.00044057134073227644, 0.0007862555794417858, 0.001151303411461413, 0.0015042456798255444, 0.0018144058994948864, 0.0020546778105199337, 0.0022040086332708597, 0.0022493551950901747, 0.0021869370248168707, 0.0020226610358804464, 0.001771679031662643, 0.0014571018982678652, 0.001107984920963645, 0.0007567567517980933, 0.00043632005690597, 0.00017708228551782668, 4.184204499324551e-06, -6.482117169070989e-05, -2.1626005036523566e-05, 0.00013199505337979645, 0.00038425053935498, 0.000714303576387465, 0.0010940695647150278, 0.0014906852738931775, 0.0018694340251386166, 0.0021968635264784098, 0.0024438209366053343, 0.00258812727406621, 0.0026166464667767286, 0.002526558004319668, 0.002325707348063588, 0.002032000105828047, 0.0016718767583370209, 0.0012780050747096539, 0.0008863864932209253, 0.0005331351421773434, 0.0002512139326427132, 6.742602272424847e-05, -6.670561703003841e-08, 5.6531833251938224e-05, 0.00023384756059385836, 0.0005175332771614194, 0.0008834590553306043, 0.0012997979065403342, 0.0017298271413892508, 0.002135198563337326, 0.0024793888442218304, 0.0027310154400765896, 0.002866723109036684, 0.002873372985050082, 0.002749326638877392, 0.0025047091767191887, 0.0021606069058179855, 0.0017472694162279367, 0.0013014663709327579, 0.0008632280514575541, 0.0004722595040220767, 0.00016434959252364933, -3.1902756745694205e-05, -9.774423233466223e-05, -2.6060050004161894e-05, 0.000177866910235025, 0.0004967096610926092, 0.0009025422623381019, 0.0013592569157481194, 0.0018257448682561517, 0.0022595603950321674, 0.002620743354782462, 0.0028754540253430605, 0.002999094547703862, 0.002978622680529952, 0.0028138505294919014, 0.002517588436603546, 0.002114622388035059, 0.0016395949060097337, 0.0011339753400534391, 0.000642381957732141, 0.00020858203060925007, -0.00012847260222770274, -0.0003382154682185501, -0.000401314755436033, -0.0003115372091997415, -7.644776633242145e-05, 0.00028313009534031153, 0.000734857632778585, 0.001237682532519102, 0.0017454572953283787, 0.0022110561840236187, 0.002590623451396823, 0.002847570925951004, 0.002955961972475052, 0.0029029694851487875, 0.002690171590074897, 0.002333566080778837, 0.0018622773932293057, 0.001316065201535821, 0.000741845928132534, 0.00018952952814288437, -0.000292458658805117, -0.0006615708116441965, -0.0008850456215441227, -0.000942976213991642, -0.0008302498026750982, -0.0005571718793362379, -0.00014870459563098848, 0.0003576277522370219, 0.0009149910183623433, 0.0014713710406795144, 0.0019742166623473167, 0.002375184092670679, 0.0026345523074269295, 0.002724910620599985, 0.0026337741874158382, 0.00236488226801157, 0.0019380422309041023, 0.0013875240692868829, 0.0007591258035972714, 0.00010616800864227116, -0.0005152401281520724, -0.001051239320077002, -0.0014551148051396012, -0.0016915997257456183, -0.0017401971854269505, -0.0015972036635503173, -0.0012762403348460793, -0.0008072255877777934, -0.00023386174871120602, 0.00039015174843370914, 0.0010058539919555187, 0.0015542892506346107, 0.0019818360451608896, 0.002245118375867605, 0.0023150499910116196, 0.0021796352230012417, 0.0018452616641297936, 0.0013363463804125786, 0.0006933489930815995, -3.0688355764141306e-05, -0.0007747802301310003, -0.001475412049330771, -0.002072249772027135, -0.0025136321783065796, -0.002761349081993103, -0.0027942631859332323, -0.0026104352436959743, -0.0022275422234088182, -0.0016815273556858301, -0.0010235835798084736, -0.0003157217870466411, 0.00037469714879989624, 0.000980981974862516, 0.0014431490562856197, 0.0017134316731244326, 0.0017607592744752765, 0.0015737846260890365, 0.0011621701996773481, 0.0005559949786402285, -0.00019669413450174034, -0.0010339836589992046, -0.0018855039961636066, -0.0026786758098751307, -0.003345240605995059, -0.0038274896796792746, -0.004083623643964529, -0.004091749899089336, -0.003852137131616473, -0.0033874958753585815, -0.0027412401977926493, -0.0019738515838980675, -0.0011576515389606357, -0.000370431924238801, 0.0003115013532806188, 0.0008202474564313889, 0.001102570560760796, 0.0011249250965192914, 0.0008767748367972672, 0.00037188257556408644, -0.00035257614217698574, -0.0012390278279781342, -0.00221440102905035, -0.00319650094024837, -0.004101300612092018, -0.0048505100421607494, -0.005378739442676306, -0.005639607086777687, -0.005610222928225994, -0.005293621681630611, -0.004718890879303217, -0.003938946407288313, -0.00302612641826272, -0.002065956126898527, -0.0011496278457343578, -0.00036584679037332535, 0.0002072289789794013, 0.0005092255305498838, 0.0005033020861446857, 0.00017986951570492238, -0.0004420909972395748, -0.0013162666000425816, -0.0023727398365736008, -0.003523909719660878, -0.00467210728675127, -0.00571825448423624, -0.006570789963006973, -0.007154079619795084, -0.007415530737489462, -0.00733074638992548, -0.006906237918883562, -0.006179383024573326, -0.005215600598603487, -0.004102952778339386, -0.0029445921536535025, -0.0018497194396331906, -0.0009238229249604046, -0.0002590757794678211, 7.424748037010431e-05, 3.453874523984268e-05, -0.0003868329804390669, -0.0011641036253422499, -0.0022387714125216007, -0.003524240106344223, -0.004913086071610451, -0.0062863510102033615, -0.0075240544974803925, -0.008516017347574234, -0.009172014892101288, -0.009430342353880405, -0.009263982065021992, -0.008683781139552593, -0.007738265674561262, -0.006510075647383928, -0.005109229125082493, -0.0036637892480939627, -0.002308689756318927, -0.0011737020686268806, -0.0003715970378834754, 1.2426880857674405e-05, -7.092746818671003e-05, -0.0006297697545960546, -0.0016293226508423686, -0.0029940432868897915, -0.004613467026501894, -0.006351329851895571, -0.008057237602770329, -0.00957989040762186, -0.01078070979565382, -0.011546673253178596, -0.011801159009337425, -0.011511805467307568, -0.010694595053792, -0.009413689374923706, -0.0077769458293914795, -0.005927369464188814, -0.004031199496239424, -0.0022635613568127155, -0.0007929382845759392, 0.0002342054358450696, 0.0007072610314935446, 0.00056249531917274, -0.00020980961562599987, -0.0015628461260348558, -0.0033957588020712137, -0.005561039783060551, -0.007876326330006123, -0.010139684192836285, -0.012147135101258755, -0.01371091976761818, -0.01467691920697689, -0.014939647167921066, -0.014453401789069176, -0.013238479383289814, -0.011381713673472404, -0.009031110443174839, -0.006384850014001131, -0.0036754198372364044, -0.0011501191183924675, 0.0009504943154752254, 0.002414381830021739, 0.003078129142522812, 0.0028435487765818834, 0.001689191092737019, -0.0003244408580940217, -0.003056679619476199, -0.006295609287917614, -0.00977363158017397, -0.013188601471483707, -0.016228949651122093, -0.01860078237950802, -0.020054733380675316, -0.020410222932696342, -0.019574971869587898, -0.017557833343744278, -0.014473618008196354, -0.010539037175476551, -0.006059755105525255, -0.0014091524062678218, 0.0029998214449733496, 0.006747722625732422, 0.009444152936339378, 0.010762985795736313, 0.01047440990805626, 0.008471079170703888, 0.00478596705943346, -0.00039985435432754457, -0.006760628428310156, -0.013840774074196815, -0.021080568432807922, -0.027851197868585587, -0.0334969125688076, -0.03738142177462578, -0.03893526643514633, -0.03770068287849426, -0.03337056189775467, -0.025818513706326485, -0.01511747483164072, -0.001545214676298201, 0.014424055814743042, 0.0321417972445488, 0.05081973969936371, 0.06957487761974335, 0.08748193085193634, 0.10362978279590607, 0.11717810481786728, 0.12741024792194366, 0.13377882540225983, 0.13594065606594086, 0.13377882540225983, 0.12741024792194366, 0.11717810481786728, 0.10362978279590607, 0.08748193085193634, 0.06957487761974335, 0.05081973969936371, 0.0321417972445488, 0.014424055814743042, -0.001545214676298201, -0.01511747483164072, -0.025818513706326485, -0.03337056189775467, -0.03770068287849426, -0.03893526643514633, -0.03738142177462578, -0.0334969125688076, -0.027851197868585587, -0.021080568432807922, -0.013840774074196815, -0.006760628428310156, -0.00039985435432754457, 0.00478596705943346, 0.008471079170703888, 0.01047440990805626, 0.010762985795736313, 0.009444152936339378, 0.006747722625732422, 0.0029998214449733496, -0.0014091524062678218, -0.006059755105525255, -0.010539037175476551, -0.014473618008196354, -0.017557833343744278, -0.019574971869587898, -0.020410222932696342, -0.020054733380675316, -0.01860078237950802, -0.016228949651122093, -0.013188601471483707, -0.00977363158017397, -0.006295609287917614, -0.003056679619476199, -0.0003244408580940217, 0.001689191092737019, 0.0028435487765818834, 0.003078129142522812, 0.002414381830021739, 0.0009504943154752254, -0.0011501191183924675, -0.0036754198372364044, -0.006384850014001131, -0.009031110443174839, -0.011381713673472404, -0.013238479383289814, -0.014453401789069176, -0.014939647167921066, -0.01467691920697689, -0.01371091976761818, -0.012147135101258755, -0.010139684192836285, -0.007876326330006123, -0.005561039783060551, -0.0033957588020712137, -0.0015628461260348558, -0.00020980961562599987, 0.00056249531917274, 0.0007072610314935446, 0.0002342054358450696, -0.0007929382845759392, -0.0022635613568127155, -0.004031199496239424, -0.005927369464188814, -0.0077769458293914795, -0.009413689374923706, -0.010694595053792, -0.011511805467307568, -0.011801159009337425, -0.011546673253178596, -0.01078070979565382, -0.00957989040762186, -0.008057237602770329, -0.006351329851895571, -0.004613467026501894, -0.0029940432868897915, -0.0016293226508423686, -0.0006297697545960546, -7.092746818671003e-05, 1.2426880857674405e-05, -0.0003715970378834754, -0.0011737020686268806, -0.002308689756318927, -0.0036637892480939627, -0.005109229125082493, -0.006510075647383928, -0.007738265674561262, -0.008683781139552593, -0.009263982065021992, -0.009430342353880405, -0.009172014892101288, -0.008516017347574234, -0.0075240544974803925, -0.0062863510102033615, -0.004913086071610451, -0.003524240106344223, -0.0022387714125216007, -0.0011641036253422499, -0.0003868329804390669, 3.453874523984268e-05, 7.424748037010431e-05, -0.0002590757794678211, -0.0009238229249604046, -0.0018497194396331906, -0.0029445921536535025, -0.004102952778339386, -0.005215600598603487, -0.006179383024573326, -0.006906237918883562, -0.00733074638992548, -0.007415530737489462, -0.007154079619795084, -0.006570789963006973, -0.00571825448423624, -0.00467210728675127, -0.003523909719660878, -0.0023727398365736008, -0.0013162666000425816, -0.0004420909972395748, 0.00017986951570492238, 0.0005033020861446857, 0.0005092255305498838, 0.0002072289789794013, -0.00036584679037332535, -0.0011496278457343578, -0.002065956126898527, -0.00302612641826272, -0.003938946407288313, -0.004718890879303217, -0.005293621681630611, -0.005610222928225994, -0.005639607086777687, -0.005378739442676306, -0.0048505100421607494, -0.004101300612092018, -0.00319650094024837, -0.00221440102905035, -0.0012390278279781342, -0.00035257614217698574, 0.00037188257556408644, 0.0008767748367972672, 0.0011249250965192914, 0.001102570560760796, 0.0008202474564313889, 0.0003115013532806188, -0.000370431924238801, -0.0011576515389606357, -0.0019738515838980675, -0.0027412401977926493, -0.0033874958753585815, -0.003852137131616473, -0.004091749899089336, -0.004083623643964529, -0.0038274896796792746, -0.003345240605995059, -0.0026786758098751307, -0.0018855039961636066, -0.0010339836589992046, -0.00019669413450174034, 0.0005559949786402285, 0.0011621701996773481, 0.0015737846260890365, 0.0017607592744752765, 0.0017134316731244326, 0.0014431490562856197, 0.000980981974862516, 0.00037469714879989624, -0.0003157217870466411, -0.0010235835798084736, -0.0016815273556858301, -0.0022275422234088182, -0.0026104352436959743, -0.0027942631859332323, -0.002761349081993103, -0.0025136321783065796, -0.002072249772027135, -0.001475412049330771, -0.0007747802301310003, -3.0688355764141306e-05, 0.0006933489930815995, 0.0013363463804125786, 0.0018452616641297936, 0.0021796352230012417, 0.0023150499910116196, 0.002245118375867605, 0.0019818360451608896, 0.0015542892506346107, 0.0010058539919555187, 0.00039015174843370914, -0.00023386174871120602, -0.0008072255877777934, -0.0012762403348460793, -0.0015972036635503173, -0.0017401971854269505, -0.0016915997257456183, -0.0014551148051396012, -0.001051239320077002, -0.0005152401281520724, 0.00010616800864227116, 0.0007591258035972714, 0.0013875240692868829, 0.0019380422309041023, 0.00236488226801157, 0.0026337741874158382, 0.002724910620599985, 0.0026345523074269295, 0.002375184092670679, 0.0019742166623473167, 0.0014713710406795144, 0.0009149910183623433, 0.0003576277522370219, -0.00014870459563098848, -0.0005571718793362379, -0.0008302498026750982, -0.000942976213991642, -0.0008850456215441227, -0.0006615708116441965, -0.000292458658805117, 0.00018952952814288437, 0.000741845928132534, 0.001316065201535821, 0.0018622773932293057, 0.002333566080778837, 0.002690171590074897, 0.0029029694851487875, 0.002955961972475052, 0.002847570925951004, 0.002590623451396823, 0.0022110561840236187, 0.0017454572953283787, 0.001237682532519102, 0.000734857632778585, 0.00028313009534031153, -7.644776633242145e-05, -0.0003115372091997415, -0.000401314755436033, -0.0003382154682185501, -0.00012847260222770274, 0.00020858203060925007, 0.000642381957732141, 0.0011339753400534391, 0.0016395949060097337, 0.002114622388035059, 0.002517588436603546, 0.0028138505294919014, 0.002978622680529952, 0.002999094547703862, 0.0028754540253430605, 0.002620743354782462, 0.0022595603950321674, 0.0018257448682561517, 0.0013592569157481194, 0.0009025422623381019, 0.0004967096610926092, 0.000177866910235025, -2.6060050004161894e-05, -9.774423233466223e-05, -3.1902756745694205e-05, 0.00016434959252364933, 0.0004722595040220767, 0.0008632280514575541, 0.0013014663709327579, 0.0017472694162279367, 0.0021606069058179855, 0.0025047091767191887, 0.002749326638877392, 0.002873372985050082, 0.002866723109036684, 0.0027310154400765896, 0.0024793888442218304, 0.002135198563337326, 0.0017298271413892508, 0.0012997979065403342, 0.0008834590553306043, 0.0005175332771614194, 0.00023384756059385836, 5.6531833251938224e-05, -6.670561703003841e-08, 6.742602272424847e-05, 0.0002512139326427132, 0.0005331351421773434, 0.0008863864932209253, 0.0012780050747096539, 0.0016718767583370209, 0.002032000105828047, 0.002325707348063588, 0.002526558004319668, 0.0026166464667767286, 0.00258812727406621, 0.0024438209366053343, 0.0021968635264784098, 0.0018694340251386166, 0.0014906852738931775, 0.0010940695647150278, 0.000714303576387465, 0.00038425053935498, 0.00013199505337979645, -2.1626005036523566e-05, -6.482117169070989e-05, 4.184204499324551e-06, 0.00017708228551782668, 0.00043632005690597, 0.0007567567517980933, 0.001107984920963645, 0.0014571018982678652, 0.001771679031662643, 0.0020226610358804464, 0.0021869370248168707, 0.0022493551950901747, 0.0022040086332708597, 0.0020546778105199337, 0.0018144058994948864, 0.0015042456798255444, 0.001151303411461413, 0.0007862555794417858, 0.00044057134073227644, 0.00014368734264280647, -7.960865332279354e-05, -0.00021135489805601537, -0.00024196156300604343, -0.0001709932112134993, -7.124535841285251e-06, 0.00023271917598322034, 0.0005249526002444327, 0.0008415027987211943, 0.0011523640714585781, 0.001428302493877709, 0.0016434675781056285, 0.0017776768654584885, 0.0018181735649704933, 0.0017607011832296848, 0.0016098112100735307, 0.0013783748727291822, 0.0010863582137972116, 0.0007589699234813452, 0.00042435835348442197, 0.00011106407328043133, -0.00015453851665370166, -0.0003505836648400873, -0.0004616317164618522, -0.00047999448725022376, -0.0004063541709911078, -0.00024962754105217755, -2.6093835913343355e-05, 0.0002421289391350001, 0.0005291171255521476, 0.0008074972429312766, 0.0010509106796234846, 0.0012363661080598831, 0.0013462689239531755, 0.0013699502451345325, 0.0013045606901869178, 0.0011552581563591957, 0.0009346745209768414, 0.0006617195322178304, 0.0003598317562136799, 5.48398784303572e-05, -0.00022737124527338892, -0.000463179312646389, -0.0006333198398351669, -0.0007245731540024281, -0.0007308952626772225, -0.0006538952002301812, -0.0005026240833103657, -0.00029269844526425004, -4.484363671508618e-05, 0.0002170075022149831, 0.0004678868572227657, 0.0006840367568656802, 0.0008450277964584529, 0.0009355599759146571, 0.0009467880590818822, 0.0008770586573518813, 0.0007319952710531652, 0.0005239311722107232, 0.00027074673562310636, -5.7805614233075175e-06, -0.0002819604123942554, -0.0005343282828107476, -0.0007417449378408492, -0.0008872696780599654, -0.0009596408344805241, -0.0009542349143885076, -0.0008734228904359043, -0.0007262963335961103, -0.0005277951713651419, -0.00029731725226156414, -5.694255742128007e-05, 0.00017056857177522033, 0.0003638202615547925, 0.000504686264321208, 0.0005799052305519581, 0.0005822269013151526, 0.0005110091879032552, 0.0003722192195709795, 0.00017784084775485098, -5.525041706277989e-05, -0.0003068416262976825, -0.0005552216898649931, -0.0007791394600644708, -0.0009597031748853624, -0.001082052243873477, -0.0011366531252861023, -0.0011201082961633801, -0.0010354057885706425, -0.0008915972430258989, -0.0007029340486042202, -0.00048754524323157966, -0.0002657802833709866, -5.8366455050418153e-05, 0.00011545138841029257, 0.00023962203704286367, 0.0003026982885785401, 0.0002988229680340737, 0.00022820492449682206, 9.704822150524706e-05, -8.305555093102157e-05, -0.0002962122962344438, -0.0005236865836195648, -0.0007456046296283603, -0.0009427441982552409, -0.0010982519015669823, -0.001199131365865469, -0.0012373754289001226, -0.0012106394860893488, -0.0011224027257412672, -0.0009816066594794393, -0.0008018057560548186, -0.0005999144050292671, -0.00039466164889745414, -0.00020489799499046057, -4.7905406972859055e-05, 6.213724554982036e-05, 0.00011539776460267603, 0.00010723375453380868, 3.8563590351259336e-05, -8.426392014371231e-05, -0.0002500854607205838, -0.0004439649928826839, -0.0006485647754743695, -0.000845719245262444, -0.0010180700337514281, -0.0011506139999255538, -0.0012320271926000714, -0.0012556477449834347, -0.0012200322235003114, -0.001129040028899908, -0.0009914415422827005, -0.0008200904703699052, -0.0006307362345978618, -0.00044058854109607637, -0.0002667626249603927, -0.00012474702089093626, -2.7029924240196124e-05, 1.7993414076045156e-05, 6.737295279890532e-06, -5.929505641688593e-05, -0.00017369046690873802, -0.0003257431380916387, -0.0005014511989429593, -0.0006847998010925949, -0.0008592142257839441, -0.0010090488940477371, -0.0011209818767383695, -0.0011851887684315443, -0.0011961914133280516, -0.0011533125070855021, -0.001060693641193211, -0.0009268831927329302, -0.000764031836297363, -0.0005867729778401554, -0.0004108900320716202, -0.0002518925757613033, -0.000123629390145652, -3.7062196497572586e-05, 6.90995648255921e-07, -1.3039965779171325e-05, -7.627718878211454e-05, -0.00018261266814079136, -0.0003218212223146111, -0.000480810267617926, -0.0006448178901337087, -0.0007987504359334707, -0.0009285378619097173, -0.0010223854333162308, -0.0010718109551817179, -0.0010723762679845095, -0.0010240492410957813, -0.0009311680332757533, -0.000802015361841768, -0.0006480408483184874, -0.00048280894407071173, -0.0003207640256732702, -0.00017592939548194408, -6.065480556571856e-05, 1.5475459804292768e-05, 4.647655805456452e-05, 3.0467548640444875e-05, -3.019636460521724e-05, -0.00012917233107145876, -0.0002567333576735109, -0.000400670018279925, -0.0005474060890264809, -0.000683227670378983, -0.0007955125765874982, -0.000873852870427072, -0.0009109669481404126, -0.0009033253882080317, -0.0008514338987879455, -0.0007597528165206313, -0.0006362624117173254, -0.0004917170736007392, -0.0003386578755453229, -0.0001902728690765798, -5.9210084145888686e-05, 4.355053897597827e-05, 0.00010966602712869644, 0.00013415426656138152, 0.00011581026046769693, 5.728051473852247e-05, -3.520865357131697e-05, -0.00015244088717736304, -0.0002830623707268387, -0.00041461814544163644, -0.0005346784018911421, -0.000631951552350074, -0.0006972865667194128, -0.0007244734442792833, -0.0007107739802449942, -0.0006571360863745213, -0.0005680762114934623, -0.00045124307507649064, -0.0003167043614666909, -0.00017602372099645436, -4.121094025322236e-05, 7.635740621481091e-05, 0.00016695157682988793, 0.00022334537061396986, 0.0002414409682387486, 0.00022060779156163335, 0.00016370757657568902, 7.68065729062073e-05, -3.1397066777572036e-05, -0.00015037640696391463, -0.0002687354863155633, -0.00037523845094256103, -0.0004598147061187774, -0.0005144511233083904, -0.000533891434315592, -0.0005160822765901685, -0.0004623286076821387, -0.0003771465562749654, -0.0002678296295925975, -0.000143770725117065, -1.5601344784954563e-05, 0.00010577180364634842, 0.00021014634694438428, 0.00028893182752653956, 0.0003359043621458113, 0.00034774289815686643, 0.0003242998500354588, 0.00026858560158871114, 0.00018646965327207, 8.612875535618514e-05, -2.2706955860485323e-05, -0.00012963998597115278, -0.00022454325517173856, -0.00029846493271179497, -0.00034441996831446886, -0.00035799789475277066, -0.0003377344983164221, -0.0002852161996997893, -0.0002049098548013717, -0.00010373636905569583, 9.571765986038372e-06, 0.00012526949285529554, 0.00023348143440671265, 0.00032508763251826167, 0.00039253366412594914, 0.0004304929170757532, 0.00043632296728901565, 0.0004102776583749801, 0.000355457334080711, 0.00027750476147048175, 0.00018407592142466456, 8.41354631120339e-05, -1.2858749869337771e-05, -9.780747495824471e-05, -0.00016278207476716489, -0.00020172400400042534, -0.0002109702763846144, -0.00018955928680952638, -0.00013929196575190872, -6.454461981775239e-05, 2.8147018383606337e-05, 0.00013069348642602563, 0.00023419078206643462, 0.00032972556073218584, 0.0004091738082934171, 0.00046592095168307424, 0.0004954406758770347, 0.0004956803168170154, 0.0004672218346968293, 0.00041320465970784426, 0.0003390204510651529, 0.00025180887314490974, 0.00015980139141902328, 7.157367508625612e-05, -4.726030056190211e-06, -6.210276478668675e-05, -9.533060801913962e-05, -0.00010140412632608786, -7.978652865858749e-05, -3.2434378226753324e-05, 3.640136128524318e-05, 0.00012057791172992438, 0.0002126290200976655, 0.00030444629373960197, 0.0003880118892993778, 0.00045611560926772654, 0.0005029935273341835, 0.0005248301313258708, 0.0005200817831791937, 0.0004895931924693286, 0.00043649881263263524, 0.00036592036485671997, 0.0002844887494575232, 0.00019973571761511266, 0.00011941047705477104, 5.0783542974386364e-05, 3.51210506973328e-18, -2.846001552825328e-05, -3.2166582968784496e-05, -1.0937817933154292e-05, 3.316560105304234e-05, 9.604676597518846e-05, 0.0001719593274174258, 0.0002540381974540651, 0.00033492551301606, 0.0004074345051776618, 0.0004651917552109808, 0.0005032000481151044, 0.000518272805493325, 0.000509302131831646, 0.0004773373657371849, 0.00042547055636532605, 0.00035853913868777454, 0.00028267601737752557, 0.00020474726625252515, 0.00013173020852264017, 7.00871751178056e-05, 2.5191977329086512e-05, 8.592020890318963e-07, -9.819989372772397e-07, 1.955791776708793e-05, 6.035899423295632e-05, 0.00011750155681511387, 0.00018563521734904498, 0.00025847231154330075, 0.00032936051138676703, 0.0003918823495041579, 0.0004404278297442943, 0.00047068900312297046, 0.0004800328169949353, 0.0004677206161431968, 0.0004349552618805319, 0.00038475438486784697, 0.00032166182063519955, 0.0002513255749363452, 0.0001799808524083346, 0.000113885966129601, 5.876150680705905e-05, 1.9283435904071666e-05, -1.3250649999463349e-06, -1.567642698319105e-06, 1.8208704204880632e-05, 5.586338011198677e-05, 0.000107672116428148, 0.00016867661906871945, 0.00023314125428441912, 0.00029507477302104235, 0.00034876956488005817, 0.0003893100656569004, 0.0004130051238462329, 0.00041770620737224817, 0.0004029842675663531, 0.0003701507521327585, 0.0003221223596483469, 0.00026314370916225016, 0.00019839350716210902, 0.0001335113774985075, 7.408810051856562e-05, 2.5165438273688778e-05, -9.209626114170533e-06, -2.6337054805480875e-05, -2.5091607312788256e-05, -6.007293904986e-06, 2.878765735658817e-05, 7.577796350233257e-05, 0.00013039057375863194, 0.0001874152512755245, 0.00024147793010342866, 0.0002875237842090428, 0.00032126670703291893, 0.00033956533297896385, 0.00034069246612489223, 0.00032447517151013017, 0.00029229410574771464, 0.0002469438186381012, 0.00019236763182561845, 0.00013329264766070992, 7.479827763745561e-05, 2.1857722458662465e-05, -2.1106228814460337e-05, -5.0611368351383135e-05, -6.441795994760469e-05, -6.171609129523858e-05, -4.318306309869513e-05, -1.0906911484198645e-05, 3.18155980494339e-05, 8.078711107373238e-05, 0.0001312951644649729, 0.00017853983445093036, 0.00021806448057759553, 0.0002461514377500862, 0.0002601469459477812, 0.0002586877380963415, 0.00024180917534977198, 0.0002109273918904364, 0.00016869770479388535, 0.00011876358621520922, 6.541986658703536e-05, 1.3221219887782354e-05, -3.342843410791829e-05, -7.066860416671261e-05, -9.552198025630787e-05, -0.00010615149221848696, -0.00010201230179518461, -8.388663991354406e-05, -5.379924550652504e-05, -1.482251627749065e-05, 2.9210070351837203e-05, 7.405558426398784e-05, 0.00011544608423719183, 0.00014947113231755793, 0.00017292411939706653, 0.00018358175293542445, 0.00018039240967482328, 0.0001635575172258541, 0.00013449981634039432, 9.572259295964614e-05, 5.057366797700524e-05, 2.936369355666102e-06, -4.312403325457126e-05, -8.372631418751553e-05, -0.00011551872739801183, -0.0001359732123091817, -0.00014360259228851646, -0.00013808207586407661, -0.00012026543845422566, -9.209529525833204e-05, -5.6417098676320165e-05, -1.671416248427704e-05, 2.321137799299322e-05, 5.958261317573488e-05, 8.898576925275847e-05, 0.00010867184028029442, 0.0001167952868854627, 0.00011256911238888279, 9.63234415394254e-05, 6.946341454749927e-05, 3.433116580708884e-05, -6.014348855387652e-06, -4.807940058526583e-05, -8.82531821844168e-05, -0.00012313239858485758, -0.00014982355060055852, -0.00016619627422187477, -0.00017106524319387972, -0.00016428546223323792, -0.0001467534457333386, -0.00012031484948238358, -8.758847252465785e-05, -5.172277087694965e-05, -1.6107947885757312e-05, 1.5930381778161973e-05, 4.142820762353949e-05, 5.8044308389071375e-05, 6.426264008041471e-05, 5.951855564489961e-05, 4.42382697656285e-05, 1.978922591661103e-05, -1.1653270121314563e-05, -4.731022272608243e-05, -8.405475091421977e-05, -0.00011869613081216812, -0.00014826613187324256, -0.00017028216097969562, -0.00018296382040716708, -0.00018538405129220337, -0.00017754205327946693, -0.00016035250155255198, -0.00013555274927057326, -0.00010553775791777298, -7.313774403883144e-05, -4.1359806346008554e-05, -1.3116551599523518e-05, 9.033461537910625e-06, 2.3110545953386463e-05, 2.7884190785698593e-05, 2.2974245439399965e-05, 8.87478563527111e-06, -1.3100625437800772e-05, -4.094634277862497e-05, -7.21525211702101e-05, -0.00010393584670964628, -0.000133492038003169, -0.00015824708680156618, -0.0001760849409038201, -0.0001855314039858058, -0.0001858782779891044, -0.00017723756900522858, -0.00016052142018452287, -0.00013735084212385118, -0.00010990190639859065, -8.070425246842206e-05, -5.2410374337341636e-05, -2.7556679924600758e-05, -8.337940926139709e-06, 3.584946398405009e-06, 7.227024525491288e-06, 2.3590787350258324e-06, -1.0481203389645088e-05, -3.0046867323108017e-05, -5.450211756397039e-05, -8.159397111739963e-05, -0.00010885907977353781, -0.00013384694466367364, -0.0001543389807920903, -0.00016854441491886973, -0.00017525505973026156, -0.0001739463332341984, -0.00016481555940117687, -0.00014875536726322025, -0.00012726504064630717, -0.00010230873886030167, -7.613384514115751e-05, -5.106633034301922e-05, -2.9301572794793174e-05, -1.2709603652183432e-05, -2.6718914796219906e-06, 3.6045939566520246e-08, -4.693715254688868e-06, -1.6300396964652464e-05, -3.3613290725043043e-05, -5.49643809790723e-05, -7.834402640582994e-05, -0.00010158524673897773, -0.00012255972251296043, -0.00013936776667833328, -0.00015050548245199025, -0.0001549942244309932, -0.0001524613908259198, -0.00014316602027975023, -0.0001279673888348043, -0.00010824033233802766, -8.574556704843417e-05, -6.246707198442891e-05, -4.043173248646781e-05, -2.1527368517126888e-05, -7.3356818575121e-06, 1.0052012839878444e-06, 2.8967210710106883e-06, -1.6737170653868816e-06, -1.2139395948906895e-05, -2.7412706913310103e-05, -4.5989414502400905e-05, -6.608883268199861e-05, -8.58168859849684e-05, -0.00010333715181332082, -0.00011703440395649523, -0.00012565632641781121, -0.00012842063733842224, -0.00012507883366197348, -0.00011593141971388832, -0.00010179344826610759, -8.39148269733414e-05, -6.386260793078691e-05, -4.337649079388939e-05, -2.4210876290453598e-05, -7.977710993145593e-06, 3.995769020548323e-06, 1.0781870514620095e-05, 1.1929958418477327e-05, 7.500213996536331e-06, -1.948789531525108e-06, -1.541693927720189e-05, -3.15581783070229e-05, -4.8805730330059305e-05, -6.551537808263674e-05, -8.011365571292117e-05, -9.12377072381787e-05, -9.785428846953437e-05, -9.934768604580313e-05, -9.556899749441072e-05, -8.684297790750861e-05, -7.393238774966449e-05, -5.796361801913008e-05, -4.032088691019453e-05, -2.251874866487924e-05, -6.064823537599295e-06, 7.674970220250543e-06, 1.7596585166756995e-05, 2.2952870494918898e-05, 2.3415330360876396e-05, 1.9097511540167034e-05, 1.0538541573623661e-05, -1.3512187706510304e-06, -1.537695061415434e-05, -3.0170369427651167e-05, -4.431464185472578e-05, -5.647184661938809e-05, -6.550156103912741e-05, -7.0560046879109e-05, -7.117145287338644e-05, -6.726505671394989e-05, -5.917573798797093e-05, -4.7608144086552784e-05, -3.3568256185390055e-05, -1.8269038264406845e-05, -3.0189148674253374e-06, 1.0896656931436155e-05, 2.2329815692501143e-05, 3.0370925742317922e-05, 3.44264080922585e-05, 3.426715556997806e-05, 3.0043587685213424e-05, 2.2266560335992835e-05, 1.175628221972147e-05, -4.3567803231781e-07, -1.3123918506607879e-05, -2.5097258912865072e-05, -3.5227465559728444e-05, -4.256894317222759e-05, -4.644056025426835e-05, -4.6482593461405486e-05, -4.2684070649556816e-05, -3.537843804224394e-05, -2.520855014154222e-05, -1.306444846704835e-05, -1.154525449249583e-18, 1.2863850315625314e-05, 2.4440359993604943e-05, 3.377365646883845e-05, 4.01221914216876e-05, 4.302177330828272e-05, 4.2322775698266923e-05, 3.8198639231268317e-05, 3.1125346140470356e-05, 2.1834146537003107e-05, 1.1242164873692673e-05, 3.674749962101487e-07, -9.763532034412492e-06, -1.820807665353641e-05, -2.4189990654122084e-05, -2.7166512154508382e-05, -2.687313281057868e-05, -2.3342865461017936e-05, -1.689855162112508e-05, -8.119410267681815e-06, 2.2148660718812607e-06, 1.3197029147704598e-05, 2.3875447368482128e-05, 3.333992208354175e-05, 4.080240978510119e-05, 4.5665543439099565e-05, 4.757293936563656e-05, 4.64372023998294e-05, 4.24433674197644e-05, 3.602789729484357e-05, 2.7835611035698093e-05, 1.8658573026186787e-05, 9.362889613839798e-06, 8.100366812868742e-07, -6.2200851971283555e-06, -1.1097540664195549e-05, -1.3396202120929956e-05, -1.2928469004691578e-05, -9.758076885191258e-06, -4.1902058001141995e-06, 3.2598416055407142e-06, 1.1916238690901082e-05, 2.100576057273429e-05, 2.972856418637093e-05, 3.733015910256654e-05, 4.316811464377679e-05, 4.676759635913186e-05, 4.786100907949731e-05, 4.6408367779804394e-05, 4.259702473063953e-05, 3.682104215840809e-05, 2.9642400477314368e-05, 2.1737896531703882e-05, 1.3836650396115147e-05, 6.654040134890238e-06, 8.279725989268627e-07, -3.1367799238068983e-06, -4.911387804895639e-06, -4.369277576188324e-06, -1.5939012882881798e-06, 3.1324211704486515e-06, 9.357248927699402e-06, 1.650148260523565e-05, 2.3913382392493077e-05, 3.092813494731672e-05, 3.6927525798091665e-05, 4.1394403524463996e-05, 4.395708310767077e-05, 4.4420023186830804e-05, 4.277812331565656e-05, 3.921376992366277e-05, 3.407715121284127e-05, 2.7851936465594918e-05, 2.1109623048687354e-05, 1.4456856661126949e-05, 8.480575161229353e-06, 3.695910891110543e-06, 5.014769612898817e-07, -8.541096008229943e-07, -2.9166966442062403e-07, 2.0946104086760897e-06, 6.0488296185212675e-06, 1.1179269677086268e-05, 1.6995962141663767e-05, 2.295633385074325e-05, 2.8514712539617904e-05, 3.317116352263838e-05, 3.651533916126937e-05, 3.826146348728798e-05, 3.8271518860710785e-05, 3.656479384517297e-05, 3.331315019750036e-05, 2.8822760214097798e-05, 2.3504155251430348e-05, 1.783354309736751e-05, 1.230898760695709e-05, 7.405470569210593e-06, 3.5329023830854567e-06, 1.0007673836298636e-06, -7.560434056586018e-09, 5.512821985576011e-07, 2.5795425244723447e-06, 5.8498894759395625e-06, 1.0028312317444943e-05, 1.470611368858954e-05, 1.9437922674114816e-05, 2.378226963628549e-05, 2.7340962333255447e-05, 2.979380587930791e-05, 3.092568658757955e-05, 3.064364500460215e-05, 2.8982729418203235e-05, 2.610025512694847e-05, 2.225926255050581e-05, 1.7802831280278042e-05, 1.3121795745973941e-05, 8.618821993877646e-06, 4.672200248023728e-06, 1.6025414879550226e-06, -3.5465379255583684e-07, -1.0682515494409017e-06, -5.209981850384793e-07, 1.1913505204574903e-06, 3.870990894938586e-06, 7.237927093228791e-06, 1.0956759979308117e-05, 1.4667851246485952e-05, 1.8020000425167382e-05, 2.070166010526009e-05, 2.2467922462965362e-05, 2.3160977434599772e-05, 2.2722317225998268e-05, 2.119581404258497e-05, 1.8721548258326948e-05, 1.5521185559919104e-05, 1.187636280519655e-05, 8.10220171842957e-06, 4.5184015107224695e-06, 1.4205753586793435e-06, -9.456205702917941e-07, -2.405310624453705e-06, -2.8684185053862166e-06, -2.335785211471375e-06, -8.970121712081891e-07, 1.2795828752132365e-06, 3.963827111874707e-06, 6.885694801894715e-06, 9.760372449818533e-06, 1.2314062587392982e-05, 1.4308200661616866e-05, 1.5559957319055684e-05, 1.5957275536493398e-05, 1.546720159240067e-05, 1.4136979189061094e-05, 1.2087900358892512e-05, 9.502701686869841e-06, 6.607760951737873e-06, 3.6518088109005475e-06, 8.831636932882247e-07, -1.4724533912158222e-06, -3.2315354019374354e-06, -4.268148131814087e-06, -4.523765255726175e-06, -4.010820248367963e-06, -2.8098238544771448e-06, -1.0604628641885938e-06, 1.0523798437134246e-06, 3.3162962154165143e-06, 5.511041763384128e-06, 7.428423032251885e-06, 8.890609024092555e-06, 9.765241884451825e-06, 9.976094588637352e-06, 9.508433322480414e-06, 8.40872417029459e-06, 6.778876922908239e-06, 4.765669473272283e-06, 2.5464371447014855e-06, 3.1240253406394913e-07, -1.748790850797377e-06, -3.469760713414871e-06, -4.717804131360026e-06, -5.405817319115158e-06, -5.49883861822309e-06, -5.01574049849296e-06, -4.0260492824018e-06, -2.642325398483081e-06, -1.008888261821994e-06, 7.119813858480484e-07, 2.3550635432911804e-06, 3.767059524761862e-06, 4.819963578484021e-06, 5.421784408099484e-06, 5.523731488210615e-06, 5.123323717270978e-06, 4.263251867087092e-06, 3.0262312975537498e-06, 1.526411665508931e-06, -1.0177357268048581e-07, -1.7162476524390513e-06, -3.1802364901523106e-06, -4.374350737634813e-06, -5.206741661822889e-06, -5.6204771681223065e-06, -5.597560630121734e-06, -5.159329248272115e-06, -4.363313109934097e-06, -3.296945124020567e-06, -2.0687832602561684e-06, -7.9811326259005e-07, 3.9607505186722847e-07, 1.4057347925700014e-06, 2.14308033719135e-06, 2.5477820599917322e-06, 2.5914587240549736e-06, 2.2791518858866766e-06, 1.647745079935703e-06, 7.615768140567525e-07, -2.942677497230761e-07, -1.4223023754311725e-06, -2.521813939893036e-06, -3.4980116652150173e-06, -4.270321824151324e-06, -4.779114988195943e-06, -4.990310571884038e-06, -4.8975130084727425e-06, -4.521584742178675e-06, -3.9077708606782835e-06, -3.12073962049908e-06, -2.23805022869783e-06, -1.3427033991320059e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_2_6</value></param>
<param><key>value</key><value>[-9.615174576538266e-07, -8.16419820637293e-09, 7.834178745724785e-07, 1.314200744673144e-06, 1.5122734566830331e-06, 1.3424432836472988e-06, 8.118428809211764e-07, -2.927675168962196e-08, -1.0918416819549748e-06, -2.2570229702978395e-06, -3.38917448061693e-06, -4.351246843725676e-06, -5.020930530008627e-06, -5.3056510296300985e-06, -5.154580321686808e-06, -4.566139068629127e-06, -3.5899395243177423e-06, -2.322744421690004e-06, -8.987047976916074e-07, 5.251562811281474e-07, 1.7866675534605747e-06, 2.737448767220485e-06, 3.260863877585507e-06, 3.2868395010154927e-06, 2.8016829674015753e-06, 1.8515785313866218e-06, 5.3914106956654e-07, -9.867970902632806e-07, -2.547178155509755e-06, -3.952789938921342e-06, -5.026176495448453e-06, -5.622870958177373e-06, -5.649412742059212e-06, -5.075935860077152e-06, -3.941668637708062e-06, -2.352481487832847e-06, -4.705169658336672e-07, 1.503106545897026e-06, 3.350705355842365e-06, 4.863066351390444e-06, 5.864240392838838e-06, 6.233178282855079e-06, 5.919561317568878e-06, 4.951795290253358e-06, 3.4360098197794287e-06, 1.545892700960394e-06, -4.956827979185618e-07, -2.441342530801194e-06, -4.0474765228282195e-06, -5.102873274154263e-06, -5.454367965285201e-06, -5.0264202400285285e-06, -3.8321386455208994e-06, -1.974233782675583e-06, 3.6450353491090937e-07, 2.940364538517315e-06, 5.4755487326474395e-06, 7.68971676734509e-06, 9.332698027719744e-06, 1.0214565008936916e-05, 1.0229449799226131e-05, 9.370183761348017e-06, 7.731768164376263e-06, 5.502984095073771e-06, 2.9468199045368237e-06, 3.7169607480791456e-07, -1.903374709399941e-06, -3.5857726743415697e-06, -4.444133537617745e-06, -4.336947313277051e-06, -3.2313989777321694e-06, -1.209979814120743e-06, 1.53619771481317e-06, 4.726949555333704e-06, 8.023464033612981e-06, 1.106636136682937e-05, 1.3517104889615439e-05, 1.5098008589120582e-05, 1.5626137610524893e-05, 1.5036970580695197e-05, 1.3394832421909086e-05, 1.0888535143749323e-05, 7.81238850322552e-06, 4.534437266556779e-06, 1.455319420529122e-06, -1.0376508043918875e-06, -2.6159632398048416e-06, -3.049606903005042e-06, -2.236221916973591e-06, -2.160551417773604e-07, 2.8293645755184116e-06, 6.595054401259404e-06, 1.0685213965189178e-05, 1.4657219253422227e-05, 1.8072070815833285e-05, 2.0545618099276908e-05, 2.1794536223751493e-05, 2.1671625290764496e-05, 2.0186045730952173e-05, 1.7505786672700197e-05, 1.3941711586085148e-05, 9.914551810652483e-06, 5.908410457777791e-06, 2.4158057385648135e-06, -1.194724745801068e-07, -1.3551079973694868e-06, -1.0923517947958317e-06, 6.976723625484738e-07, 3.866864972223993e-06, 8.103497748379596e-06, 1.296489699598169e-05, 1.7926093278219923e-05, 2.2439078747993335e-05, 2.5996065232902765e-05, 2.8189379008836113e-05, 2.876101825677324e-05, 2.7635831429506652e-05, 2.4934141038102098e-05, 2.096187563438434e-05, 1.6178917576326057e-05, 1.1148838893859647e-05, 6.475561349361669e-06, 2.7339658572600456e-06, 4.0244344745588023e-07, -1.9473061740882258e-07, 1.0717044460761826e-06, 4.116931449971162e-06, 8.647494723845739e-06, 1.4191115951689426e-05, 2.014789788518101e-05, 2.585743641247973e-05, 3.067430225200951e-05, 3.404331800993532e-05, 3.5565881262300536e-05, 3.504940468701534e-05, 3.25337823596783e-05, 2.8291406124481e-05, 2.2800137230660766e-05, 1.6691861674189568e-05, 1.0682118045224342e-05, 5.488646820595022e-06, 1.7480426777183311e-06, -5.97721836470555e-08, 3.296349859738257e-07, 2.9302850634849165e-06, 7.499275398004102e-06, 1.3559987564804032e-05, 2.045289693342056e-05, 2.740859599725809e-05, 3.3635005820542574e-05, 3.8408867112593725e-05, 4.1160998080158606e-05, 4.1545288695488125e-05, 3.9483093132730573e-05, 3.517739241942763e-05, 2.9094555429765023e-05, 2.191513340221718e-05, 1.4458892110269517e-05, 7.592268502776278e-06, 2.1286678020260297e-06, -1.2669145235122414e-06, -2.1578337054961594e-06, -3.9069917079359584e-07, 3.88158605346689e-06, 1.0211912922386546e-05, 1.7905424101627432e-05, 2.609558214317076e-05, 3.384154479135759e-05, 4.023592919111252e-05, 4.451068161870353e-05, 4.612866905517876e-05, 4.48501123173628e-05, 4.076579352840781e-05, 3.429237403906882e-05, 2.612996286188718e-05, 1.718593375699129e-05, 8.473378329654224e-06, 9.954977713277913e-07, -4.3709255805879366e-06, -6.979444606258767e-06, -6.4929836298688315e-06, -2.9283658022905e-06, 3.3394080674042925e-06, 1.1614364666456822e-05, 2.0954634237568825e-05, 3.027736056537833e-05, 3.8481757655972615e-05, 4.457643808564171e-05, 4.7796176659176126e-05, 4.7694527893327177e-05, 4.420104232849553e-05, 3.763585846172646e-05, 2.867928378691431e-05, 1.8299069779459387e-05, 7.643136086699087e-06, -2.09041945709032e-06, -9.791332558961585e-06, -1.4567333892046008e-05, -1.5851228454266675e-05, -1.3472103091771714e-05, -7.681780516577419e-06, 8.67279993599368e-07, 1.1190891200385522e-05, 2.208164551120717e-05, 3.224510874133557e-05, 4.0448336221743375e-05, 4.566374991554767e-05, 4.719156277133152e-05, 4.474626257433556e-05, 3.849646600428969e-05, 2.9052851459709927e-05, 1.740461084409617e-05, 4.811054623132804e-06, -7.339876901824027e-06, -1.769029586284887e-05, -2.507014141883701e-05, -2.863573536160402e-05, -2.797276283672545e-05, -2.315116216777824e-05, -1.4724800166732166e-05, -3.6750629988091532e-06, 8.695967153471429e-06, 2.0911204046569765e-05, 3.148683026665822e-05, 3.9104041206883267e-05, 4.276436447980814e-05, 4.191037442069501e-05, 3.6497178371064365e-05, 2.7005702577298507e-05, 1.4395263860933483e-05, -1.8041038702401517e-18, -1.4619744433730375e-05, -2.785452306852676e-05, -3.823137376457453e-05, -4.4586427975445986e-05, -4.6204480895539746e-05, -4.2908657633233815e-05, -3.5089240554952994e-05, -2.3667165805818513e-05, -9.995578693633433e-06, 4.29020838055294e-06, 1.7457708963775076e-05, 2.7876341846422292e-05, 3.4207743738079444e-05, 3.5565131838666275e-05, 3.162284701829776e-05, 2.266253977722954e-05, 9.549764399707783e-06, -6.357347047014628e-06, -2.3357863028650172e-05, -3.959972309530713e-05, -5.3291798394639045e-05, -6.291206955211237e-05, -6.738776573911309e-05, -6.622613000217825e-05, -5.958014662610367e-05, -4.824026473215781e-05, -3.355244916747324e-05, -1.7270564057980664e-05, -1.3594158190244343e-06, 1.222948958456982e-05, 2.1783996999147348e-05, 2.6032943424070254e-05, 2.4299708456965163e-05, 1.6589221559115686e-05, 3.597356226237025e-06, -1.335949946223991e-05, -3.248770008212887e-05, -5.17168955411762e-05, -6.893554382259026e-05, -8.223451732192189e-05, -9.013088856590912e-05, -9.174551087198779e-05, -8.691344555700198e-05, -7.621312397532165e-05, -6.09101407462731e-05, -4.282053487258963e-05, -2.4108565412461758e-05, -7.041302978905151e-06, 6.27220742899226e-06, 1.4127155736787245e-05, 1.5425908713950776e-05, 9.813562428462319e-06, -2.270498498546658e-06, -1.9632216208265163e-05, -4.045032983412966e-05, -6.247818237170577e-05, -8.329755655722693e-05, -0.00010059592023026198, -0.00011243524932069704, -0.00011748140241252258, -0.00011516660742927343, -0.00010576585191302001, -9.03765539987944e-05, -7.080305658746511e-05, -4.935762262903154e-05, -2.8600039513548836e-05, -1.1044960956496652e-05, 1.1295318245174713e-06, 6.338413186313119e-06, 3.781136001634877e-06, -6.455072252720129e-06, -2.339316051802598e-05, -4.526709744823165e-05, -6.971530092414469e-05, -9.404556476511061e-05, -0.00011554182128747925, -0.0001317777787335217, -0.00014090124750509858, -0.00014185599866323173, -0.00013451439735945314, -0.00011970468040090054, -9.91278575384058e-05, -7.517271296819672e-05, -5.064871584181674e-05, -2.8466851290431805e-05, -1.1304424333502539e-05, -1.2924027714689146e-06, 2.3817570138362498e-07, -7.07932531440747e-06, -2.2591990273213014e-05, -4.468935003387742e-05, -7.097689376678318e-05, -9.854249219642952e-05, -0.00012428616173565388, -0.0001452758879167959, -0.00015908858040347695, -0.00016409681120421737, -0.00015966709179338068, -0.0001462461077608168, -0.0001253228692803532, -9.927024802891538e-05, -7.108202407835051e-05, -4.4034906750312075e-05, -2.1313438992365263e-05, -5.6407639021927025e-06, 1.0420535545563325e-06, -2.189594852097798e-06, -1.5123953744478058e-05, -3.6422799894353375e-05, -6.376168312272057e-05, -9.408590267412364e-05, -0.00012395413068588823, -0.00014993120566941798, -0.00016898497415240854, -0.00017884181579574943, -0.0001782587933121249, -0.000167180405696854, -0.00014675971760880202, -0.00011924040882149711, -8.771120337769389e-05, -5.575950490310788e-05, -2.7063146262662485e-05, -4.966566848452203e-06, 7.909801752248313e-06, 9.981325092667248e-06, 8.951722634265025e-07, -1.8413593352306634e-05, -4.581403118208982e-05, -7.821065810276195e-05, -0.00011188911594217643, -0.00014293759886641055, -0.00016769624198786914, -0.00018318311776965857, -0.00018744684348348528, -0.00017980474513024092, -0.00016093718295451254, -0.00013282563304528594, -9.853964002104476e-05, -6.189553096191958e-05, -2.7024583687307313e-05, 2.100294068441144e-06, 2.2125455870991573e-05, 3.071140599786304e-05, 2.6815314413397573e-05, 1.0827172445715405e-05, -1.5457959307241254e-05, -4.903033186565153e-05, -8.599849388701841e-05, -0.00012202819198137149, -0.00015283757238648832, -0.00017469240992795676, -0.00018484389875084162, -0.00018185791850555688, -0.00016579627117607743, -0.00013822746404912323, -0.00010206337174167857, -6.12389703746885e-05, -2.026999936788343e-05, 1.6261676137219183e-05, 4.423639984452166e-05, 6.047794158803299e-05, 6.313141784630716e-05, 5.1893057388952e-05, 2.8063472200301476e-05, -5.583655820373679e-06, -4.5104650780558586e-05, -8.582755253883079e-05, -0.00012288308062124997, -0.00015176467422861606, -0.00016885309014469385, -0.00017184464377351105, -0.00016003259224817157, -0.00013440723705571145, -9.756131476024166e-05, -5.340915231499821e-05, -6.750068223482231e-06, 3.7275600334396586e-05, 7.377602742053568e-05, 9.867552580544725e-05, 0.00010919455962721258, 0.00010418540477985516, 8.428343426203355e-05, 5.185409463592805e-05, 1.0739543540694285e-05, -3.416809704503976e-05, -7.747964264126495e-05, -0.0001139254163717851, -0.00013896501332055777, -0.00014931990881450474, -0.00014336618187371641, -0.00012134091230109334, -8.533582149539143e-05, -3.907684367732145e-05, 1.2487540516303852e-05, 6.374374788720161e-05, 0.00010905358794843778, 0.00014340483176056296, 0.00016299674462061375, 0.00016569241415709257, 0.0001512839226052165, 0.00012153791612945497, 8.001359674381092e-05, 3.1671814213041216e-05, -1.768207221175544e-05, -6.205895624589175e-05, -9.597540338290855e-05, -0.00011509221803862602, -0.0001167281370726414, -0.00010018763714469969, -6.686336564598605e-05, -2.0098392269574106e-05, 3.517801815178245e-05, 9.300187230110168e-05, 0.00014705132343806326, 0.00019137233903165907, 0.00022106998949311674, 0.00023288471857085824, 0.00022558646742254496, 0.00020013883477076888, 0.0001596114889252931, 0.00010884885705308989, 5.3930194553686306e-05, 1.4813176676398143e-06, -4.2084313463419676e-05, -7.13081462890841e-05, -8.232695108745247e-05, -7.333605026360601e-05, -4.4819920731242746e-05, 4.789524723491922e-07, 5.785209941677749e-05, 0.00012114720448153093, 0.00018346248543821275, 0.0002379350917181, 0.00027853326173499227, 0.0003007613413501531, 0.0003021948505192995, 0.00028278224635869265, 0.0002448761370033026, 0.00019298731058370322, 0.00013328701606951654, 7.29124149074778e-05, 1.915309803734999e-05, -2.1388555978774093e-05, -4.356667704996653e-05, -4.430120679899119e-05, -2.2955273379920982e-05, 1.856540075095836e-05, 7.600548269692808e-05, 0.00014322616334538907, 0.00021289358846843243, 0.0002773123560473323, 0.00032930957968346775, 0.0003630679566413164, 0.0003748109156731516, 0.0003632596926763654, 0.0003298067895229906, 0.00027838326059281826, 0.00021503116295207292, 0.0001472285221097991, 8.304127550218254e-05, 3.019859650521539e-05, -4.802457624464296e-06, -1.745944973663427e-05, -5.80482219447731e-06, 2.9340766559471376e-05, 8.443418482784182e-05, 0.00015359041572082788, 0.00022923722281120718, 0.0003029712534043938, 0.000366519030649215, 0.0004126924031879753, 0.00043622899102047086, 0.0004344188782852143, 0.00040744346915744245, 0.00035838354961015284, 0.0002928938192781061, 0.00021857656247448176, 0.00014412417658604681, 7.83276409492828e-05, 2.9063103283988312e-05, 2.373915776843205e-06, 1.7547289417052525e-06, 2.7722406230168417e-05, 7.77261084294878e-05, 0.0001464104134356603, 0.00022620457457378507, 0.0003081734466832131, 0.0003830342902801931, 0.00044222388532944024, 0.0004788937221746892, 0.0004887167015112936, 0.0004704119637608528, 0.00042592271347530186, 0.000360224541509524, 0.00028078159084543586, 0.00019671050540637225, 0.00011774515587603673, 5.3119962103664875e-05, 1.0499660675122868e-05, -4.920549599773949e-06, 8.961099410953466e-06, 5.087965109851211e-05, 0.00011631580127868801, 0.00019798475841525942, 0.00028664906858466566, 0.00037216447526589036, 0.00044464116217568517, 0.0004955865442752838, 0.0005188988870941103, 0.0005115942331030965, 0.00047418137546628714, 0.00041063764365389943, 0.0003279837837908417, 0.00023550451442133635, 0.0001436994643881917, 6.3084349676501e-05, 2.9780608201690484e-06, -2.9583809009636752e-05, -3.068280057050288e-05, 3.637384055046274e-18, 5.911196785746142e-05, 0.00013997976202517748, 0.0002333465381525457, 0.00032841440406627953, 0.0004140745149925351, 0.00048018537927418947, 0.0005187516217119992, 0.0005248668021522462, 0.0004973094328306615, 0.0004387190565466881, 0.00035532936453819275, 0.00025628419825807214, 0.00015261063526850194, 5.5966000218177214e-05, -2.270078402943909e-05, -7.441848720191047e-05, -9.324720303993672e-05, -7.699249545112252e-05, -2.749434315774124e-05, 4.954625910613686e-05, 0.00014518777607008815, 0.0002482481941115111, 0.00034657304058782756, 0.0004284277092665434, 0.0004838547029066831, 0.0005058386013843119, 0.0004911435535177588, 0.0004407218948472291, 0.0003596445603761822, 0.00025655547506175935, 0.00014270874089561403, 3.0695788154844195e-05, -6.699386722175404e-05, -0.0001394136343151331, -0.000178436646820046, -0.00017971950001083314, -0.00014323880895972252, -7.333452231250703e-05, 2.1749210645793937e-05, 0.00013077798939775676, 0.00024079439754132181, 0.0003385959134902805, 0.0004122548853047192, 0.0004525059775914997, 0.0004538395151030272, 0.00041517207864671946, 0.00034001306630671024, 0.00023610300559084862, 0.00011456094944151118, -1.1365843420207966e-05, -0.00012780942779500037, -0.00022187407012097538, -0.0002831321908161044, -0.00030484938179142773, -0.00028479532920755446, -0.0002255425788462162, -0.00013421461335383356, -2.1706760890083387e-05, 9.85351434792392e-05, 0.0002120413992088288, 0.0003049772640224546, 0.00036574414116330445, 0.00038633751682937145, 0.0003633032611105591, 0.0002981781435664743, 0.0001973588514374569, 7.140959496609867e-05, -6.611721619265154e-05, -0.00020021569798700511, -0.0003161428903695196, -0.0004011207784060389, -0.00044582714326679707, -0.00044550211168825626, -0.0004005384398624301, -0.0003164835798088461, -0.00020344705262687057, -7.497672049794346e-05, 5.3471703722607344e-05, 0.0001662992435740307, 0.00024956074776127934, 0.00029258790891617537, 0.0002892491756938398, 0.00023869835422374308, 0.0001455205347156152, 1.9253280697739683e-05, -0.0001266675244551152, -0.0002764207310974598, -0.0004136019852012396, -0.0005231090472079813, -0.0005928945611231029, -0.0006153822178021073, -0.0005883804988116026, -0.0005153841339051723, -0.000405222293920815, -0.000271089025773108, -0.00012906167830806226, 3.726500835909974e-06, 0.00011105226440122351, 0.00017948077584151179, 0.0001999397500185296, 0.00016880490875337273, 8.836712368065491e-05, -3.337791349622421e-05, -0.00018359987006988376, -0.00034606875851750374, -0.0005029949243180454, -0.0006370653863996267, -0.0007334435940720141, -0.0007815012941136956, -0.0007760815205983818, -0.000718141789548099, -0.0006146981613710523, -0.0004780708986800164, -0.0003245112020522356, -0.00017236359417438507, -3.996927625848912e-05, 5.6447923270752653e-05, 0.0001046708639478311, 9.793341450858861e-05, 3.574935544747859e-05, -7.597528019687161e-05, -0.0002255655126646161, -0.00039687141543254256, -0.0005710893892683089, -0.0007289053755812347, -0.0008527164463885128, -0.0009286747663281858, -0.0009483162430115044, -0.0009095845744013786, -0.000817124149762094, -0.0006818049005232751, -0.0005195235717110336, -0.00034941654303111136, -0.00019168238213751465, -6.526309152832255e-05, 1.4350588571687695e-05, 3.693547478178516e-05, -1.2388414916131296e-06, -9.692223102319986e-05, -0.00024019651755224913, -0.00041555939242243767, -0.0006036611157469451, -0.0007835010183043778, -0.0009348320891149342, -0.0010405021021142602, -0.0010884563671424985, -0.0010731725487858057, -0.0009963542688637972, -0.0008667984511703253, -0.0006994437426328659, -0.0005137023981660604, -0.00033126247581094503, -0.00017360810306854546, -5.954128209850751e-05, -2.990981784023461e-06, -1.1364828424120788e-05, -8.463767153443769e-05, -0.00021528886281885207, -0.000389102817280218, -0.0005867481813766062, -0.0007859607576392591, -0.000964083184953779, -0.001100672292523086, -0.001179874874651432, -0.001192294294014573, -0.0011361303040757775, -0.0010174522176384926, -0.0008495692745782435, -0.0006515594432130456, -0.0004461210919544101, -0.00025698920944705606, -0.0001062082956195809, -1.157730548584368e-05, 1.543913640489336e-05, -2.891239091695752e-05, -0.00014017385547049344, -0.00030611749389208853, -0.0005080866976641119, -0.0007230897317640483, -0.0009264113614335656, -0.0010944453533738852, -0.0012074251426383853, -0.0012517349096015096, -0.001221531885676086, -0.001119488151744008, -0.0009565566433593631, -0.0007507810951210558, -0.0005252786795608699, -0.00030562016763724387, -0.00011690430255839601, 1.9138557036058046e-05, 8.668036753078923e-05, 7.767092756694183e-05, -7.166383511503227e-06, -0.0001583413250045851, -0.00035861379001289606, -0.0005849127192050219, -0.0008109440677799284, -0.0010101923253387213, -0.001158974482677877, -0.0012391931377351284, -0.0012404717272147536, -0.0011614169925451279, -0.001009857514873147, -0.000802022754214704, -0.000560745713301003, -0.0003128892567474395, -8.628592331660911e-05, 9.34610579861328e-05, 0.0002059475373243913, 0.0002383651299169287, 0.00018704334797803313, 5.795233664684929e-05, -0.00013390103413257748, -0.0003661237424239516, -0.0006114525021985173, -0.0008408531430177391, -0.0010268507758155465, -0.0011467098956927657, -0.0011850947048515081, -0.0011359021300449967, -0.0010030452394858003, -0.000800089561380446, -0.0005487747839652002, -0.0002765807439573109, -1.3611220310849603e-05, 0.00021085196931380779, 0.0003717302461154759, 0.000451074680313468, 0.00044019639608450234, 0.00034074863651767373, 0.00016462642815895379, -6.73147733323276e-05, -0.0003275840717833489, -0.0005851650494150817, -0.0008090594201348722, -0.0009718590881675482, -0.0010529357241466641, -0.001040878240019083, -0.000934887386392802, -0.0007449620170518756, -0.0004908410483039916, -0.00019981450168415904, 9.635433525545523e-05, 0.0003650498983915895, 0.0005765547975897789, 0.0007074991590343416, 0.0007436092710122466, 0.0006814312655478716, 0.0005288244574330747, 0.00030415423680096865, 3.42679450113792e-05, -0.0002485245349816978, -0.0005101260612718761, -0.0007185658905655146, -0.0008477026713080704, -0.0008802882512100041, -0.0008100336417555809, -0.0006424308521673083, -0.00039422366535291076, -9.157800377579406e-05, 0.00023284951748792082, 0.0005436173523776233, 0.0008065578294917941, 0.000992724671959877, 0.001081775058992207, 0.0010643883142620325, 0.0009434372186660767, 0.0007337647257372737, 0.0004605786525644362, 0.00015663840167690068, -0.0001414532889612019, -0.000397434487240389, -0.0005795658216811717, -0.0006643286324106157, -0.0006392078939825296, -0.0005042327102273703, -0.000272084929747507, 3.324951831018552e-05, 0.00037914328277111053, 0.0007280097925104201, 0.001041589886881411, 0.0012853535590693355, 0.0014325116062536836, 0.001467171125113964, 0.0013862636405974627, 0.0012000123970210552, 0.0009308726876042783, 0.0006110535468906164, 0.00027889275224879384, -2.5506358724669553e-05, -0.0002648805093485862, -0.000409126456361264, -0.00043883436592295766, -0.00034762112773023546, -0.00014298345195129514, 0.00015444059681612998, 0.0005131308571435511, 0.000894218566827476, 0.0012558980379253626, 0.001558217336423695, 0.0017676973948255181, 0.0018612486310303211, 0.001828923705033958, 0.0016751833027228713, 0.001418511150404811, 0.0010894116712734103, 0.000727002159692347, 0.0003745843714568764, 7.469127740478143e-05, -0.00013582104293163866, -0.00023007296840660274, -0.000194350111996755, -2.9804366931784898e-05, 0.00024754228070378304, 0.0006085075438022614, 0.0010139902587980032, 0.0014193847309798002, 0.0017796697793528438, 0.0020545911975204945, 0.0022133449092507362, 0.002238211687654257, 0.002126720268279314, 0.0018920698203146458, 0.0015617553144693375, 0.0011745296651497483, 0.0007760414737276733, 0.0004136385687161237, 0.00013092687004245818, -3.7289868487278e-05, -6.91028981236741e-05, 4.185623038210906e-05, 0.0002855364291463047, 0.0006364714936353266, 0.0010565700940787792, 0.0014993868535384536, 0.001915395027026534, 0.002257664455100894, 0.002487293677404523, 0.002577967708930373, 0.0025191069580614567, 0.002317235805094242, 0.0019953902810811996, 0.0015906201442703605, 0.00114984973333776, 0.0007245650631375611, 0.00036492268554866314, 0.00011395649198675528, 2.5505241865175776e-06, 4.576348510454409e-05, 0.0002409417793387547, 0.0005678554880432785, 0.0009908609790727496, 0.00146285945083946, 0.0019306151662021875, 0.0023408301640301943, 0.0026462848763912916, 0.002811337821185589, 0.0028161455411463976, 0.0026590998750180006, 0.0023571907076984644, 0.0019442281918600202, 0.0014671081444248557, 0.000980535987764597, 0.0005407974240370095, 0.00019928684923797846, -3.463969051153981e-06, -4.2563748138491064e-05, 8.821540541248396e-05, 0.00037553615402430296, 0.0007878395263105631, 0.0012788018211722374, 0.0017925259890034795, 0.0022698892280459404, 0.0026553228963166475, 0.002903253072872758, 0.0029834506567567587, 0.0028846694622188807, 0.0026161305140703917, 0.0022066659294068813, 0.001701590372249484, 0.001157646533101797, 0.0006365787703543901, 0.00019806802447419614, -0.0001071682563633658, -0.00024331237364094704, -0.00019372654787730426, 3.69336994481273e-05, 0.0004230382910463959, 0.0009207214461639524, 0.0014727500965818763, 0.0020149825140833855, 0.002483689459040761, 0.002822903450578451, 0.002990948734804988, 0.002965394640341401, 0.002745838835835457, 0.0023541836999356747, 0.0018323451513424516, 0.0012376302620396018, 0.0006362935528159142, 9.599465556675568e-05, -0.00032198583357967436, -0.0005698772147297859, -0.0006190681015141308, -0.0004636084195226431, -0.00012113613774999976, 0.0003689030709210783, 0.0009495691629126668, 0.001552803092636168, 0.0021071515511721373, 0.0025459672324359417, 0.0028151420410722494, 0.002879480831325054, 0.0027269632555544376, 0.0023703835904598236, 0.0018461450235918164, 0.0012103250483050942, 0.0005324257654137909, -0.00011248887312831357, -0.0006523842457681894, -0.0010265926830470562, -0.0011929329484701157, -0.0011327795218676329, -0.000853472447488457, -0.00038776372093707323, 0.00020967326418031007, 0.0008682981715537608, 0.0015096563147380948, 0.0020563325379043818, 0.00244088820181787, 0.0026137500535696745, 0.002549128606915474, 0.0022482681088149548, 0.001739612896926701, 0.0010758439311757684, 0.0003280891105532646, -0.00042206363286823034, -0.001091848243959248, -0.001606849255040288, -0.0019096783362329006, -0.0019667926244437695, -0.0017726430669426918, -0.0013506487011909485, -0.0007508413400501013, -4.441615965333767e-05, 0.0006842221482656896, 0.0013470317935571074, 0.0018624409567564726, 0.0021648318506777287, 0.0022123015951365232, 0.001991784665733576, 0.0015209141420200467, 0.0008463689009658992, 3.885148908011615e-05, -0.000814764411188662, -0.0016212482005357742, -0.002291681943461299, -0.0027517674025148153, -0.002950576599687338, -0.002866721712052822, -0.0025111958384513855, -0.0019265207229182124, -0.001182248117402196, -0.0003672879538498819, 0.0004200935654807836, 0.0010834840359166265, 0.001539467484690249, 0.0017274150159209967, 0.0016167769208550453, 0.00121100596152246, 0.0005476119113154709, -0.00030570782837457955, -0.0012584688374772668, -0.0022075260058045387, -0.0030487964395433664, -0.0036892492789775133, -0.00405778456479311, -0.004113735165446997, -0.003851974615827203, -0.003304003272205591, -0.0025348260533064604, -0.0016359227010980248, -0.0007150716846808791, 0.00011585062020458281, 0.0007537155761383474, 0.0011161622824147344, 0.0011513971257954836, 0.0008446096326224506, 0.00022022004122845829, -0.0006603626534342766, -0.001705279340967536, -0.0028023652266710997, -0.0038317833095788956, -0.004679732955992222, -0.0052516646683216095, -0.005483477376401424, -0.005349373910576105, -0.004865420050919056, -0.004088336601853371, -0.003109585028141737, -0.002045354573056102, -0.0010235479567199945, -0.00016921035421546549, 0.00040994156734086573, 0.0006362222484312952, 0.0004714219248853624, -7.814710261300206e-05, -0.0009616541210561991, -0.0020888845901936293, -0.0033399974927306175, -0.004578859079629183, -0.005668475292623043, -0.00648677721619606, -0.006940960418432951, -0.006978683173656464, -0.006594800855964422, -0.0058327713049948215, -0.00478048762306571, -0.0035609127953648567, -0.00231851264834404, -0.0012029685312882066, -0.0003520021855365485, 0.000124730882816948, 0.00015880279534030706, -0.0002683363272808492, -0.0011222973698750138, -0.002318734535947442, -0.0037321404088288546, -0.005209547467529774, -0.006587652955204248, -0.007711459882557392, -0.008452322334051132, -0.008723295293748379, -0.008489989675581455, -0.007775580044835806, -0.006659281440079212, -0.0052683367393910885, -0.003764319932088256, -0.002325192093849182, -0.0011251111282035708, -0.0003142588248010725, -1.006712068374327e-06, -0.00023852198501117527, -0.001017445931211114, -0.002265616087242961, -0.0038550132885575294, -0.005615294445306063, -0.007352496962994337, -0.00887087918817997, -0.009995459578931332, -0.010592682287096977, -0.01058677677065134, -0.009969868697226048, -0.008804487064480782, -0.007218054495751858, -0.005389753729104996, -0.0035311412066221237, -0.0018625441007316113, -0.0005878715892322361, 0.0001293159875785932, 0.00018570787506178021, -0.00044827768579125404, -0.0017231418751180172, -0.0035139056853950024, -0.005632482469081879, -0.007847637869417667, -0.009910451248288155, -0.011582508683204651, -0.012663684785366058, -0.013016294687986374, -0.012582788243889809, -0.0113947419449687, -0.009571884758770466, -0.007310987915843725, -0.004865568596869707, -0.0025184692349284887, -0.0005502167623490095, 0.0007933476008474827, 0.001330499304458499, 0.0009666731930337846, -0.0002917176461778581, -0.00233456096611917, -0.004957098513841629, -0.007880120538175106, -0.01077937986701727, -0.01332120131701231, -0.01520046778023243, -0.01617673598229885, -0.016104338690638542, -0.014952825382351875, -0.012815065681934357, -0.009901645593345165, -0.006521633826196194, -0.003051362233236432, 0.0001057254703482613, 0.0025640304666012526, 0.004000678192824125, 0.00419529527425766, 0.0030599988531321287, 0.0006558154127560556, -0.0028069117106497288, -0.006984897423535585, -0.011434036307036877, -0.015654439106583595, -0.01914404332637787, -0.02145528420805931, -0.022248759865760803, -0.021337848156690598, -0.018718961626291275, -0.014583351090550423, -0.009308231994509697, -0.0034270407631993294, 0.0024191527627408504, 0.007544958498328924, 0.011292871087789536, 0.013107308186590672, 0.01260290015488863, 0.00961970817297697, 0.004258983768522739, -0.003105201292783022, -0.011840914376080036, -0.021099865436553955, -0.029882734641432762, -0.0371231883764267, -0.041783407330513, -0.04295250400900841, -0.039938732981681824, -0.032346516847610474, -0.020130567252635956, -0.0036211940459907055, 0.016482459381222725, 0.03915175795555115, 0.06309788674116135, 0.08686579018831253, 0.10894493013620377, 0.127887561917305, 0.1424241065979004, 0.15156565606594086, 0.15468455851078033, 0.15156565606594086, 0.1424241065979004, 0.127887561917305, 0.10894493013620377, 0.08686579018831253, 0.06309788674116135, 0.03915175795555115, 0.016482459381222725, -0.0036211940459907055, -0.020130567252635956, -0.032346516847610474, -0.039938732981681824, -0.04295250400900841, -0.041783407330513, -0.0371231883764267, -0.029882734641432762, -0.021099865436553955, -0.011840914376080036, -0.003105201292783022, 0.004258983768522739, 0.00961970817297697, 0.01260290015488863, 0.013107308186590672, 0.011292871087789536, 0.007544958498328924, 0.0024191527627408504, -0.0034270407631993294, -0.009308231994509697, -0.014583351090550423, -0.018718961626291275, -0.021337848156690598, -0.022248759865760803, -0.02145528420805931, -0.01914404332637787, -0.015654439106583595, -0.011434036307036877, -0.006984897423535585, -0.0028069117106497288, 0.0006558154127560556, 0.0030599988531321287, 0.00419529527425766, 0.004000678192824125, 0.0025640304666012526, 0.0001057254703482613, -0.003051362233236432, -0.006521633826196194, -0.009901645593345165, -0.012815065681934357, -0.014952825382351875, -0.016104338690638542, -0.01617673598229885, -0.01520046778023243, -0.01332120131701231, -0.01077937986701727, -0.007880120538175106, -0.004957098513841629, -0.00233456096611917, -0.0002917176461778581, 0.0009666731930337846, 0.001330499304458499, 0.0007933476008474827, -0.0005502167623490095, -0.0025184692349284887, -0.004865568596869707, -0.007310987915843725, -0.009571884758770466, -0.0113947419449687, -0.012582788243889809, -0.013016294687986374, -0.012663684785366058, -0.011582508683204651, -0.009910451248288155, -0.007847637869417667, -0.005632482469081879, -0.0035139056853950024, -0.0017231418751180172, -0.00044827768579125404, 0.00018570787506178021, 0.0001293159875785932, -0.0005878715892322361, -0.0018625441007316113, -0.0035311412066221237, -0.005389753729104996, -0.007218054495751858, -0.008804487064480782, -0.009969868697226048, -0.01058677677065134, -0.010592682287096977, -0.009995459578931332, -0.00887087918817997, -0.007352496962994337, -0.005615294445306063, -0.0038550132885575294, -0.002265616087242961, -0.001017445931211114, -0.00023852198501117527, -1.006712068374327e-06, -0.0003142588248010725, -0.0011251111282035708, -0.002325192093849182, -0.003764319932088256, -0.0052683367393910885, -0.006659281440079212, -0.007775580044835806, -0.008489989675581455, -0.008723295293748379, -0.008452322334051132, -0.007711459882557392, -0.006587652955204248, -0.005209547467529774, -0.0037321404088288546, -0.002318734535947442, -0.0011222973698750138, -0.0002683363272808492, 0.00015880279534030706, 0.000124730882816948, -0.0003520021855365485, -0.0012029685312882066, -0.00231851264834404, -0.0035609127953648567, -0.00478048762306571, -0.0058327713049948215, -0.006594800855964422, -0.006978683173656464, -0.006940960418432951, -0.00648677721619606, -0.005668475292623043, -0.004578859079629183, -0.0033399974927306175, -0.0020888845901936293, -0.0009616541210561991, -7.814710261300206e-05, 0.0004714219248853624, 0.0006362222484312952, 0.00040994156734086573, -0.00016921035421546549, -0.0010235479567199945, -0.002045354573056102, -0.003109585028141737, -0.004088336601853371, -0.004865420050919056, -0.005349373910576105, -0.005483477376401424, -0.0052516646683216095, -0.004679732955992222, -0.0038317833095788956, -0.0028023652266710997, -0.001705279340967536, -0.0006603626534342766, 0.00022022004122845829, 0.0008446096326224506, 0.0011513971257954836, 0.0011161622824147344, 0.0007537155761383474, 0.00011585062020458281, -0.0007150716846808791, -0.0016359227010980248, -0.0025348260533064604, -0.003304003272205591, -0.003851974615827203, -0.004113735165446997, -0.00405778456479311, -0.0036892492789775133, -0.0030487964395433664, -0.0022075260058045387, -0.0012584688374772668, -0.00030570782837457955, 0.0005476119113154709, 0.00121100596152246, 0.0016167769208550453, 0.0017274150159209967, 0.001539467484690249, 0.0010834840359166265, 0.0004200935654807836, -0.0003672879538498819, -0.001182248117402196, -0.0019265207229182124, -0.0025111958384513855, -0.002866721712052822, -0.002950576599687338, -0.0027517674025148153, -0.002291681943461299, -0.0016212482005357742, -0.000814764411188662, 3.885148908011615e-05, 0.0008463689009658992, 0.0015209141420200467, 0.001991784665733576, 0.0022123015951365232, 0.0021648318506777287, 0.0018624409567564726, 0.0013470317935571074, 0.0006842221482656896, -4.441615965333767e-05, -0.0007508413400501013, -0.0013506487011909485, -0.0017726430669426918, -0.0019667926244437695, -0.0019096783362329006, -0.001606849255040288, -0.001091848243959248, -0.00042206363286823034, 0.0003280891105532646, 0.0010758439311757684, 0.001739612896926701, 0.0022482681088149548, 0.002549128606915474, 0.0026137500535696745, 0.00244088820181787, 0.0020563325379043818, 0.0015096563147380948, 0.0008682981715537608, 0.00020967326418031007, -0.00038776372093707323, -0.000853472447488457, -0.0011327795218676329, -0.0011929329484701157, -0.0010265926830470562, -0.0006523842457681894, -0.00011248887312831357, 0.0005324257654137909, 0.0012103250483050942, 0.0018461450235918164, 0.0023703835904598236, 0.0027269632555544376, 0.002879480831325054, 0.0028151420410722494, 0.0025459672324359417, 0.0021071515511721373, 0.001552803092636168, 0.0009495691629126668, 0.0003689030709210783, -0.00012113613774999976, -0.0004636084195226431, -0.0006190681015141308, -0.0005698772147297859, -0.00032198583357967436, 9.599465556675568e-05, 0.0006362935528159142, 0.0012376302620396018, 0.0018323451513424516, 0.0023541836999356747, 0.002745838835835457, 0.002965394640341401, 0.002990948734804988, 0.002822903450578451, 0.002483689459040761, 0.0020149825140833855, 0.0014727500965818763, 0.0009207214461639524, 0.0004230382910463959, 3.69336994481273e-05, -0.00019372654787730426, -0.00024331237364094704, -0.0001071682563633658, 0.00019806802447419614, 0.0006365787703543901, 0.001157646533101797, 0.001701590372249484, 0.0022066659294068813, 0.0026161305140703917, 0.0028846694622188807, 0.0029834506567567587, 0.002903253072872758, 0.0026553228963166475, 0.0022698892280459404, 0.0017925259890034795, 0.0012788018211722374, 0.0007878395263105631, 0.00037553615402430296, 8.821540541248396e-05, -4.2563748138491064e-05, -3.463969051153981e-06, 0.00019928684923797846, 0.0005407974240370095, 0.000980535987764597, 0.0014671081444248557, 0.0019442281918600202, 0.0023571907076984644, 0.0026590998750180006, 0.0028161455411463976, 0.002811337821185589, 0.0026462848763912916, 0.0023408301640301943, 0.0019306151662021875, 0.00146285945083946, 0.0009908609790727496, 0.0005678554880432785, 0.0002409417793387547, 4.576348510454409e-05, 2.5505241865175776e-06, 0.00011395649198675528, 0.00036492268554866314, 0.0007245650631375611, 0.00114984973333776, 0.0015906201442703605, 0.0019953902810811996, 0.002317235805094242, 0.0025191069580614567, 0.002577967708930373, 0.002487293677404523, 0.002257664455100894, 0.001915395027026534, 0.0014993868535384536, 0.0010565700940787792, 0.0006364714936353266, 0.0002855364291463047, 4.185623038210906e-05, -6.91028981236741e-05, -3.7289868487278e-05, 0.00013092687004245818, 0.0004136385687161237, 0.0007760414737276733, 0.0011745296651497483, 0.0015617553144693375, 0.0018920698203146458, 0.002126720268279314, 0.002238211687654257, 0.0022133449092507362, 0.0020545911975204945, 0.0017796697793528438, 0.0014193847309798002, 0.0010139902587980032, 0.0006085075438022614, 0.00024754228070378304, -2.9804366931784898e-05, -0.000194350111996755, -0.00023007296840660274, -0.00013582104293163866, 7.469127740478143e-05, 0.0003745843714568764, 0.000727002159692347, 0.0010894116712734103, 0.001418511150404811, 0.0016751833027228713, 0.001828923705033958, 0.0018612486310303211, 0.0017676973948255181, 0.001558217336423695, 0.0012558980379253626, 0.000894218566827476, 0.0005131308571435511, 0.00015444059681612998, -0.00014298345195129514, -0.00034762112773023546, -0.00043883436592295766, -0.000409126456361264, -0.0002648805093485862, -2.5506358724669553e-05, 0.00027889275224879384, 0.0006110535468906164, 0.0009308726876042783, 0.0012000123970210552, 0.0013862636405974627, 0.001467171125113964, 0.0014325116062536836, 0.0012853535590693355, 0.001041589886881411, 0.0007280097925104201, 0.00037914328277111053, 3.324951831018552e-05, -0.000272084929747507, -0.0005042327102273703, -0.0006392078939825296, -0.0006643286324106157, -0.0005795658216811717, -0.000397434487240389, -0.0001414532889612019, 0.00015663840167690068, 0.0004605786525644362, 0.0007337647257372737, 0.0009434372186660767, 0.0010643883142620325, 0.001081775058992207, 0.000992724671959877, 0.0008065578294917941, 0.0005436173523776233, 0.00023284951748792082, -9.157800377579406e-05, -0.00039422366535291076, -0.0006424308521673083, -0.0008100336417555809, -0.0008802882512100041, -0.0008477026713080704, -0.0007185658905655146, -0.0005101260612718761, -0.0002485245349816978, 3.42679450113792e-05, 0.00030415423680096865, 0.0005288244574330747, 0.0006814312655478716, 0.0007436092710122466, 0.0007074991590343416, 0.0005765547975897789, 0.0003650498983915895, 9.635433525545523e-05, -0.00019981450168415904, -0.0004908410483039916, -0.0007449620170518756, -0.000934887386392802, -0.001040878240019083, -0.0010529357241466641, -0.0009718590881675482, -0.0008090594201348722, -0.0005851650494150817, -0.0003275840717833489, -6.73147733323276e-05, 0.00016462642815895379, 0.00034074863651767373, 0.00044019639608450234, 0.000451074680313468, 0.0003717302461154759, 0.00021085196931380779, -1.3611220310849603e-05, -0.0002765807439573109, -0.0005487747839652002, -0.000800089561380446, -0.0010030452394858003, -0.0011359021300449967, -0.0011850947048515081, -0.0011467098956927657, -0.0010268507758155465, -0.0008408531430177391, -0.0006114525021985173, -0.0003661237424239516, -0.00013390103413257748, 5.795233664684929e-05, 0.00018704334797803313, 0.0002383651299169287, 0.0002059475373243913, 9.34610579861328e-05, -8.628592331660911e-05, -0.0003128892567474395, -0.000560745713301003, -0.000802022754214704, -0.001009857514873147, -0.0011614169925451279, -0.0012404717272147536, -0.0012391931377351284, -0.001158974482677877, -0.0010101923253387213, -0.0008109440677799284, -0.0005849127192050219, -0.00035861379001289606, -0.0001583413250045851, -7.166383511503227e-06, 7.767092756694183e-05, 8.668036753078923e-05, 1.9138557036058046e-05, -0.00011690430255839601, -0.00030562016763724387, -0.0005252786795608699, -0.0007507810951210558, -0.0009565566433593631, -0.001119488151744008, -0.001221531885676086, -0.0012517349096015096, -0.0012074251426383853, -0.0010944453533738852, -0.0009264113614335656, -0.0007230897317640483, -0.0005080866976641119, -0.00030611749389208853, -0.00014017385547049344, -2.891239091695752e-05, 1.543913640489336e-05, -1.157730548584368e-05, -0.0001062082956195809, -0.00025698920944705606, -0.0004461210919544101, -0.0006515594432130456, -0.0008495692745782435, -0.0010174522176384926, -0.0011361303040757775, -0.001192294294014573, -0.001179874874651432, -0.001100672292523086, -0.000964083184953779, -0.0007859607576392591, -0.0005867481813766062, -0.000389102817280218, -0.00021528886281885207, -8.463767153443769e-05, -1.1364828424120788e-05, -2.990981784023461e-06, -5.954128209850751e-05, -0.00017360810306854546, -0.00033126247581094503, -0.0005137023981660604, -0.0006994437426328659, -0.0008667984511703253, -0.0009963542688637972, -0.0010731725487858057, -0.0010884563671424985, -0.0010405021021142602, -0.0009348320891149342, -0.0007835010183043778, -0.0006036611157469451, -0.00041555939242243767, -0.00024019651755224913, -9.692223102319986e-05, -1.2388414916131296e-06, 3.693547478178516e-05, 1.4350588571687695e-05, -6.526309152832255e-05, -0.00019168238213751465, -0.00034941654303111136, -0.0005195235717110336, -0.0006818049005232751, -0.000817124149762094, -0.0009095845744013786, -0.0009483162430115044, -0.0009286747663281858, -0.0008527164463885128, -0.0007289053755812347, -0.0005710893892683089, -0.00039687141543254256, -0.0002255655126646161, -7.597528019687161e-05, 3.574935544747859e-05, 9.793341450858861e-05, 0.0001046708639478311, 5.6447923270752653e-05, -3.996927625848912e-05, -0.00017236359417438507, -0.0003245112020522356, -0.0004780708986800164, -0.0006146981613710523, -0.000718141789548099, -0.0007760815205983818, -0.0007815012941136956, -0.0007334435940720141, -0.0006370653863996267, -0.0005029949243180454, -0.00034606875851750374, -0.00018359987006988376, -3.337791349622421e-05, 8.836712368065491e-05, 0.00016880490875337273, 0.0001999397500185296, 0.00017948077584151179, 0.00011105226440122351, 3.726500835909974e-06, -0.00012906167830806226, -0.000271089025773108, -0.000405222293920815, -0.0005153841339051723, -0.0005883804988116026, -0.0006153822178021073, -0.0005928945611231029, -0.0005231090472079813, -0.0004136019852012396, -0.0002764207310974598, -0.0001266675244551152, 1.9253280697739683e-05, 0.0001455205347156152, 0.00023869835422374308, 0.0002892491756938398, 0.00029258790891617537, 0.00024956074776127934, 0.0001662992435740307, 5.3471703722607344e-05, -7.497672049794346e-05, -0.00020344705262687057, -0.0003164835798088461, -0.0004005384398624301, -0.00044550211168825626, -0.00044582714326679707, -0.0004011207784060389, -0.0003161428903695196, -0.00020021569798700511, -6.611721619265154e-05, 7.140959496609867e-05, 0.0001973588514374569, 0.0002981781435664743, 0.0003633032611105591, 0.00038633751682937145, 0.00036574414116330445, 0.0003049772640224546, 0.0002120413992088288, 9.85351434792392e-05, -2.1706760890083387e-05, -0.00013421461335383356, -0.0002255425788462162, -0.00028479532920755446, -0.00030484938179142773, -0.0002831321908161044, -0.00022187407012097538, -0.00012780942779500037, -1.1365843420207966e-05, 0.00011456094944151118, 0.00023610300559084862, 0.00034001306630671024, 0.00041517207864671946, 0.0004538395151030272, 0.0004525059775914997, 0.0004122548853047192, 0.0003385959134902805, 0.00024079439754132181, 0.00013077798939775676, 2.1749210645793937e-05, -7.333452231250703e-05, -0.00014323880895972252, -0.00017971950001083314, -0.000178436646820046, -0.0001394136343151331, -6.699386722175404e-05, 3.0695788154844195e-05, 0.00014270874089561403, 0.00025655547506175935, 0.0003596445603761822, 0.0004407218948472291, 0.0004911435535177588, 0.0005058386013843119, 0.0004838547029066831, 0.0004284277092665434, 0.00034657304058782756, 0.0002482481941115111, 0.00014518777607008815, 4.954625910613686e-05, -2.749434315774124e-05, -7.699249545112252e-05, -9.324720303993672e-05, -7.441848720191047e-05, -2.270078402943909e-05, 5.5966000218177214e-05, 0.00015261063526850194, 0.00025628419825807214, 0.00035532936453819275, 0.0004387190565466881, 0.0004973094328306615, 0.0005248668021522462, 0.0005187516217119992, 0.00048018537927418947, 0.0004140745149925351, 0.00032841440406627953, 0.0002333465381525457, 0.00013997976202517748, 5.911196785746142e-05, 3.637384055046274e-18, -3.068280057050288e-05, -2.9583809009636752e-05, 2.9780608201690484e-06, 6.3084349676501e-05, 0.0001436994643881917, 0.00023550451442133635, 0.0003279837837908417, 0.00041063764365389943, 0.00047418137546628714, 0.0005115942331030965, 0.0005188988870941103, 0.0004955865442752838, 0.00044464116217568517, 0.00037216447526589036, 0.00028664906858466566, 0.00019798475841525942, 0.00011631580127868801, 5.087965109851211e-05, 8.961099410953466e-06, -4.920549599773949e-06, 1.0499660675122868e-05, 5.3119962103664875e-05, 0.00011774515587603673, 0.00019671050540637225, 0.00028078159084543586, 0.000360224541509524, 0.00042592271347530186, 0.0004704119637608528, 0.0004887167015112936, 0.0004788937221746892, 0.00044222388532944024, 0.0003830342902801931, 0.0003081734466832131, 0.00022620457457378507, 0.0001464104134356603, 7.77261084294878e-05, 2.7722406230168417e-05, 1.7547289417052525e-06, 2.373915776843205e-06, 2.9063103283988312e-05, 7.83276409492828e-05, 0.00014412417658604681, 0.00021857656247448176, 0.0002928938192781061, 0.00035838354961015284, 0.00040744346915744245, 0.0004344188782852143, 0.00043622899102047086, 0.0004126924031879753, 0.000366519030649215, 0.0003029712534043938, 0.00022923722281120718, 0.00015359041572082788, 8.443418482784182e-05, 2.9340766559471376e-05, -5.80482219447731e-06, -1.745944973663427e-05, -4.802457624464296e-06, 3.019859650521539e-05, 8.304127550218254e-05, 0.0001472285221097991, 0.00021503116295207292, 0.00027838326059281826, 0.0003298067895229906, 0.0003632596926763654, 0.0003748109156731516, 0.0003630679566413164, 0.00032930957968346775, 0.0002773123560473323, 0.00021289358846843243, 0.00014322616334538907, 7.600548269692808e-05, 1.856540075095836e-05, -2.2955273379920982e-05, -4.430120679899119e-05, -4.356667704996653e-05, -2.1388555978774093e-05, 1.915309803734999e-05, 7.29124149074778e-05, 0.00013328701606951654, 0.00019298731058370322, 0.0002448761370033026, 0.00028278224635869265, 0.0003021948505192995, 0.0003007613413501531, 0.00027853326173499227, 0.0002379350917181, 0.00018346248543821275, 0.00012114720448153093, 5.785209941677749e-05, 4.789524723491922e-07, -4.4819920731242746e-05, -7.333605026360601e-05, -8.232695108745247e-05, -7.13081462890841e-05, -4.2084313463419676e-05, 1.4813176676398143e-06, 5.3930194553686306e-05, 0.00010884885705308989, 0.0001596114889252931, 0.00020013883477076888, 0.00022558646742254496, 0.00023288471857085824, 0.00022106998949311674, 0.00019137233903165907, 0.00014705132343806326, 9.300187230110168e-05, 3.517801815178245e-05, -2.0098392269574106e-05, -6.686336564598605e-05, -0.00010018763714469969, -0.0001167281370726414, -0.00011509221803862602, -9.597540338290855e-05, -6.205895624589175e-05, -1.768207221175544e-05, 3.1671814213041216e-05, 8.001359674381092e-05, 0.00012153791612945497, 0.0001512839226052165, 0.00016569241415709257, 0.00016299674462061375, 0.00014340483176056296, 0.00010905358794843778, 6.374374788720161e-05, 1.2487540516303852e-05, -3.907684367732145e-05, -8.533582149539143e-05, -0.00012134091230109334, -0.00014336618187371641, -0.00014931990881450474, -0.00013896501332055777, -0.0001139254163717851, -7.747964264126495e-05, -3.416809704503976e-05, 1.0739543540694285e-05, 5.185409463592805e-05, 8.428343426203355e-05, 0.00010418540477985516, 0.00010919455962721258, 9.867552580544725e-05, 7.377602742053568e-05, 3.7275600334396586e-05, -6.750068223482231e-06, -5.340915231499821e-05, -9.756131476024166e-05, -0.00013440723705571145, -0.00016003259224817157, -0.00017184464377351105, -0.00016885309014469385, -0.00015176467422861606, -0.00012288308062124997, -8.582755253883079e-05, -4.5104650780558586e-05, -5.583655820373679e-06, 2.8063472200301476e-05, 5.1893057388952e-05, 6.313141784630716e-05, 6.047794158803299e-05, 4.423639984452166e-05, 1.6261676137219183e-05, -2.026999936788343e-05, -6.12389703746885e-05, -0.00010206337174167857, -0.00013822746404912323, -0.00016579627117607743, -0.00018185791850555688, -0.00018484389875084162, -0.00017469240992795676, -0.00015283757238648832, -0.00012202819198137149, -8.599849388701841e-05, -4.903033186565153e-05, -1.5457959307241254e-05, 1.0827172445715405e-05, 2.6815314413397573e-05, 3.071140599786304e-05, 2.2125455870991573e-05, 2.100294068441144e-06, -2.7024583687307313e-05, -6.189553096191958e-05, -9.853964002104476e-05, -0.00013282563304528594, -0.00016093718295451254, -0.00017980474513024092, -0.00018744684348348528, -0.00018318311776965857, -0.00016769624198786914, -0.00014293759886641055, -0.00011188911594217643, -7.821065810276195e-05, -4.581403118208982e-05, -1.8413593352306634e-05, 8.951722634265025e-07, 9.981325092667248e-06, 7.909801752248313e-06, -4.966566848452203e-06, -2.7063146262662485e-05, -5.575950490310788e-05, -8.771120337769389e-05, -0.00011924040882149711, -0.00014675971760880202, -0.000167180405696854, -0.0001782587933121249, -0.00017884181579574943, -0.00016898497415240854, -0.00014993120566941798, -0.00012395413068588823, -9.408590267412364e-05, -6.376168312272057e-05, -3.6422799894353375e-05, -1.5123953744478058e-05, -2.189594852097798e-06, 1.0420535545563325e-06, -5.6407639021927025e-06, -2.1313438992365263e-05, -4.4034906750312075e-05, -7.108202407835051e-05, -9.927024802891538e-05, -0.0001253228692803532, -0.0001462461077608168, -0.00015966709179338068, -0.00016409681120421737, -0.00015908858040347695, -0.0001452758879167959, -0.00012428616173565388, -9.854249219642952e-05, -7.097689376678318e-05, -4.468935003387742e-05, -2.2591990273213014e-05, -7.07932531440747e-06, 2.3817570138362498e-07, -1.2924027714689146e-06, -1.1304424333502539e-05, -2.8466851290431805e-05, -5.064871584181674e-05, -7.517271296819672e-05, -9.91278575384058e-05, -0.00011970468040090054, -0.00013451439735945314, -0.00014185599866323173, -0.00014090124750509858, -0.0001317777787335217, -0.00011554182128747925, -9.404556476511061e-05, -6.971530092414469e-05, -4.526709744823165e-05, -2.339316051802598e-05, -6.455072252720129e-06, 3.781136001634877e-06, 6.338413186313119e-06, 1.1295318245174713e-06, -1.1044960956496652e-05, -2.8600039513548836e-05, -4.935762262903154e-05, -7.080305658746511e-05, -9.03765539987944e-05, -0.00010576585191302001, -0.00011516660742927343, -0.00011748140241252258, -0.00011243524932069704, -0.00010059592023026198, -8.329755655722693e-05, -6.247818237170577e-05, -4.045032983412966e-05, -1.9632216208265163e-05, -2.270498498546658e-06, 9.813562428462319e-06, 1.5425908713950776e-05, 1.4127155736787245e-05, 6.27220742899226e-06, -7.041302978905151e-06, -2.4108565412461758e-05, -4.282053487258963e-05, -6.09101407462731e-05, -7.621312397532165e-05, -8.691344555700198e-05, -9.174551087198779e-05, -9.013088856590912e-05, -8.223451732192189e-05, -6.893554382259026e-05, -5.17168955411762e-05, -3.248770008212887e-05, -1.335949946223991e-05, 3.597356226237025e-06, 1.6589221559115686e-05, 2.4299708456965163e-05, 2.6032943424070254e-05, 2.1783996999147348e-05, 1.222948958456982e-05, -1.3594158190244343e-06, -1.7270564057980664e-05, -3.355244916747324e-05, -4.824026473215781e-05, -5.958014662610367e-05, -6.622613000217825e-05, -6.738776573911309e-05, -6.291206955211237e-05, -5.3291798394639045e-05, -3.959972309530713e-05, -2.3357863028650172e-05, -6.357347047014628e-06, 9.549764399707783e-06, 2.266253977722954e-05, 3.162284701829776e-05, 3.5565131838666275e-05, 3.4207743738079444e-05, 2.7876341846422292e-05, 1.7457708963775076e-05, 4.29020838055294e-06, -9.995578693633433e-06, -2.3667165805818513e-05, -3.5089240554952994e-05, -4.2908657633233815e-05, -4.6204480895539746e-05, -4.4586427975445986e-05, -3.823137376457453e-05, -2.785452306852676e-05, -1.4619744433730375e-05, -1.8041038702401517e-18, 1.4395263860933483e-05, 2.7005702577298507e-05, 3.6497178371064365e-05, 4.191037442069501e-05, 4.276436447980814e-05, 3.9104041206883267e-05, 3.148683026665822e-05, 2.0911204046569765e-05, 8.695967153471429e-06, -3.6750629988091532e-06, -1.4724800166732166e-05, -2.315116216777824e-05, -2.797276283672545e-05, -2.863573536160402e-05, -2.507014141883701e-05, -1.769029586284887e-05, -7.339876901824027e-06, 4.811054623132804e-06, 1.740461084409617e-05, 2.9052851459709927e-05, 3.849646600428969e-05, 4.474626257433556e-05, 4.719156277133152e-05, 4.566374991554767e-05, 4.0448336221743375e-05, 3.224510874133557e-05, 2.208164551120717e-05, 1.1190891200385522e-05, 8.67279993599368e-07, -7.681780516577419e-06, -1.3472103091771714e-05, -1.5851228454266675e-05, -1.4567333892046008e-05, -9.791332558961585e-06, -2.09041945709032e-06, 7.643136086699087e-06, 1.8299069779459387e-05, 2.867928378691431e-05, 3.763585846172646e-05, 4.420104232849553e-05, 4.7694527893327177e-05, 4.7796176659176126e-05, 4.457643808564171e-05, 3.8481757655972615e-05, 3.027736056537833e-05, 2.0954634237568825e-05, 1.1614364666456822e-05, 3.3394080674042925e-06, -2.9283658022905e-06, -6.4929836298688315e-06, -6.979444606258767e-06, -4.3709255805879366e-06, 9.954977713277913e-07, 8.473378329654224e-06, 1.718593375699129e-05, 2.612996286188718e-05, 3.429237403906882e-05, 4.076579352840781e-05, 4.48501123173628e-05, 4.612866905517876e-05, 4.451068161870353e-05, 4.023592919111252e-05, 3.384154479135759e-05, 2.609558214317076e-05, 1.7905424101627432e-05, 1.0211912922386546e-05, 3.88158605346689e-06, -3.9069917079359584e-07, -2.1578337054961594e-06, -1.2669145235122414e-06, 2.1286678020260297e-06, 7.592268502776278e-06, 1.4458892110269517e-05, 2.191513340221718e-05, 2.9094555429765023e-05, 3.517739241942763e-05, 3.9483093132730573e-05, 4.1545288695488125e-05, 4.1160998080158606e-05, 3.8408867112593725e-05, 3.3635005820542574e-05, 2.740859599725809e-05, 2.045289693342056e-05, 1.3559987564804032e-05, 7.499275398004102e-06, 2.9302850634849165e-06, 3.296349859738257e-07, -5.97721836470555e-08, 1.7480426777183311e-06, 5.488646820595022e-06, 1.0682118045224342e-05, 1.6691861674189568e-05, 2.2800137230660766e-05, 2.8291406124481e-05, 3.25337823596783e-05, 3.504940468701534e-05, 3.5565881262300536e-05, 3.404331800993532e-05, 3.067430225200951e-05, 2.585743641247973e-05, 2.014789788518101e-05, 1.4191115951689426e-05, 8.647494723845739e-06, 4.116931449971162e-06, 1.0717044460761826e-06, -1.9473061740882258e-07, 4.0244344745588023e-07, 2.7339658572600456e-06, 6.475561349361669e-06, 1.1148838893859647e-05, 1.6178917576326057e-05, 2.096187563438434e-05, 2.4934141038102098e-05, 2.7635831429506652e-05, 2.876101825677324e-05, 2.8189379008836113e-05, 2.5996065232902765e-05, 2.2439078747993335e-05, 1.7926093278219923e-05, 1.296489699598169e-05, 8.103497748379596e-06, 3.866864972223993e-06, 6.976723625484738e-07, -1.0923517947958317e-06, -1.3551079973694868e-06, -1.194724745801068e-07, 2.4158057385648135e-06, 5.908410457777791e-06, 9.914551810652483e-06, 1.3941711586085148e-05, 1.7505786672700197e-05, 2.0186045730952173e-05, 2.1671625290764496e-05, 2.1794536223751493e-05, 2.0545618099276908e-05, 1.8072070815833285e-05, 1.4657219253422227e-05, 1.0685213965189178e-05, 6.595054401259404e-06, 2.8293645755184116e-06, -2.160551417773604e-07, -2.236221916973591e-06, -3.049606903005042e-06, -2.6159632398048416e-06, -1.0376508043918875e-06, 1.455319420529122e-06, 4.534437266556779e-06, 7.81238850322552e-06, 1.0888535143749323e-05, 1.3394832421909086e-05, 1.5036970580695197e-05, 1.5626137610524893e-05, 1.5098008589120582e-05, 1.3517104889615439e-05, 1.106636136682937e-05, 8.023464033612981e-06, 4.726949555333704e-06, 1.53619771481317e-06, -1.209979814120743e-06, -3.2313989777321694e-06, -4.336947313277051e-06, -4.444133537617745e-06, -3.5857726743415697e-06, -1.903374709399941e-06, 3.7169607480791456e-07, 2.9468199045368237e-06, 5.502984095073771e-06, 7.731768164376263e-06, 9.370183761348017e-06, 1.0229449799226131e-05, 1.0214565008936916e-05, 9.332698027719744e-06, 7.68971676734509e-06, 5.4755487326474395e-06, 2.940364538517315e-06, 3.6450353491090937e-07, -1.974233782675583e-06, -3.8321386455208994e-06, -5.0264202400285285e-06, -5.454367965285201e-06, -5.102873274154263e-06, -4.0474765228282195e-06, -2.441342530801194e-06, -4.956827979185618e-07, 1.545892700960394e-06, 3.4360098197794287e-06, 4.951795290253358e-06, 5.919561317568878e-06, 6.233178282855079e-06, 5.864240392838838e-06, 4.863066351390444e-06, 3.350705355842365e-06, 1.503106545897026e-06, -4.705169658336672e-07, -2.352481487832847e-06, -3.941668637708062e-06, -5.075935860077152e-06, -5.649412742059212e-06, -5.622870958177373e-06, -5.026176495448453e-06, -3.952789938921342e-06, -2.547178155509755e-06, -9.867970902632806e-07, 5.3914106956654e-07, 1.8515785313866218e-06, 2.8016829674015753e-06, 3.2868395010154927e-06, 3.260863877585507e-06, 2.737448767220485e-06, 1.7866675534605747e-06, 5.251562811281474e-07, -8.987047976916074e-07, -2.322744421690004e-06, -3.5899395243177423e-06, -4.566139068629127e-06, -5.154580321686808e-06, -5.3056510296300985e-06, -5.020930530008627e-06, -4.351246843725676e-06, -3.38917448061693e-06, -2.2570229702978395e-06, -1.0918416819549748e-06, -2.927675168962196e-08, 8.118428809211764e-07, 1.3424432836472988e-06, 1.5122734566830331e-06, 1.314200744673144e-06, 7.834178745724785e-07, -8.16419820637293e-09, -9.615174576538266e-07]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_bpf_2_5</value></param>
<param><key>value</key><value>[1.8032529851552681e-06, 9.355410384159768e-07, 2.908910232690687e-07, -3.3214583083918114e-08, 2.372009078044357e-08, 4.7601869823665766e-07, 1.28819908695732e-06, 2.377568762312876e-06, 3.6229555462341523e-06, 4.878683739661938e-06, 5.9922067521256395e-06, 6.82327163303853e-06, 7.262219696713146e-06, 7.245057531690691e-06, 6.763255896657938e-06, 5.866824722033925e-06, 4.660048034565989e-06, 3.2901548365771305e-06, 1.930122380144894e-06, 7.576058465019742e-07, -6.745563752019734e-08, -4.2375216935397475e-07, -2.4531701114938187e-07, 4.682254655108409e-07, 1.6494003602929297e-06, 3.1691631647845497e-06, 4.851206540479325e-06, 6.492734428320546e-06, 7.889276275818702e-06, 8.860520210873801e-06, 9.273909199691843e-06, 9.0629455371527e-06, 8.237699148594402e-06, 6.8859453676850535e-06, 5.164498816156993e-06, 3.281529643572867e-06, 1.471831524213485e-06, -3.204360865538547e-08, -1.0292475280948565e-06, -1.3769825955023407e-06, -1.0103000249728211e-06, 4.735241532216605e-08, 1.6844476249389118e-06, 3.712839543368318e-06, 5.889248768653488e-06, 7.944340723042842e-06, 9.615951057639904e-06, 1.068235815182561e-05, 1.0991414455929771e-05, 1.0481724530109204e-05, 9.192965080728754e-06, 7.263740826601861e-06, 4.916894340567524e-06, 2.433773033772013e-06, 1.2039534169616672e-07, -1.7304292896369589e-06, -2.876363396353554e-06, -3.1574586500937585e-06, -2.5185556751239346e-06, -1.0190830153078423e-06, 1.171328108284797e-06, 3.791232074945583e-06, 6.517822839668952e-06, 9.005929314298555e-06, 1.0930856660706922e-05, 1.2029784556943923e-05, 1.2136451914557256e-05, 1.1204589100088924e-05, 9.316846444562543e-06, 6.677723831671756e-06, 3.5909852158511057e-06, 4.239863926613907e-07, -2.4368948743358487e-06, -4.634361630451167e-06, -5.885854989173822e-06, -6.0209486036910675e-06, -5.005585535400314e-06, -2.9497525702026905e-06, -9.723611782419539e-08, 3.2017042030929588e-06, 6.531720373459393e-06, 9.46295949688647e-06, 1.1604701285250485e-05, 1.2655381397053134e-05, 1.2442608749552164e-05, 1.0947925147775095e-05, 8.312798854603898e-06, 4.824679763260065e-06, 8.843672389957646e-07, -3.041621539523476e-06, -6.4780679167597555e-06, -9.000497811939567e-06, -1.0289639249094762e-05, -1.0173946066061035e-05, -8.654543307784479e-06, -5.9090762078994885e-06, -2.273486643389333e-06, 1.7965134020414553e-06, 5.779869752586819e-06, 9.154059625871014e-06, 1.1460596397228073e-05, 1.2363972928142175e-05, 1.1696504770952743e-05, 9.483105714025442e-06, 5.942462848906871e-06, 1.4639203982369509e-06, -3.4375580071355216e-06, -8.18317766970722e-06, -1.2201464414829388e-05, -1.5000055100244936e-05, -1.6229148968704976e-05, -1.5728424841654487e-05, -1.3551253687182907e-05, -9.962610420188867e-06, -5.410424364526989e-06, -4.733671801204764e-07, 4.208859536447562e-06, 8.014369996089954e-06, 1.0417385965411086e-05, 1.1056136827392038e-05, 9.78162370302016e-06, 6.680759724986274e-06, 2.0704203507193597e-06, -3.537450766089023e-06, -9.495893209532369e-06, -1.5101148164831102e-05, -1.9679611796163954e-05, -2.2672786144539714e-05, -2.3709581000730395e-05, -2.2656571672996506e-05, -1.9639568563434295e-05, -1.5033110685180873e-05, -9.418606168765109e-06, -3.5157315778633347e-06, 1.9048771946472698e-06, 6.117065822763834e-06, 8.530937520845328e-06, 8.769401574681979e-06, 6.719591510773171e-06, 2.5522354007989634e-06, -3.2941100016614655e-06, -1.016265287034912e-05, -1.7256257706321776e-05, -2.3734419301035814e-05, -2.8817572456318885e-05, -3.188578921253793e-05, -3.255941192037426e-05, -3.075118729611859e-05, -2.6682790121412836e-05, -2.0863040845142677e-05, -1.4029734302312136e-05, -7.061743872327497e-06, -8.717665309632139e-07, 3.707175665113027e-06, 6.0274333009147085e-06, 5.7112256399705075e-06, 2.702968686207896e-06, -2.717712050070986e-06, -9.964663149730768e-06, -1.8212753275292926e-05, -2.6496574719203636e-05, -3.382852810318582e-05, -3.9321850636042655e-05, -4.230333070154302e-05, -4.240135967847891e-05, -3.959793320973404e-05, -3.423733141971752e-05, -2.698970820347313e-05, -1.877322756627109e-05, -1.0643819223332684e-05, -3.6656820157077163e-06, 1.2215747346999706e-06, 3.3226108371309238e-06, 2.2776478090236196e-06, -1.8865472384277382e-06, -8.75308433023747e-06, -1.7560076230438426e-05, -2.7289677746011876e-05, -3.679072324302979e-05, -4.492013977142051e-05, -5.068592508905567e-05, -5.337367838365026e-05, -5.2640727517427877e-05, -4.856538726016879e-05, -4.1644561861176044e-05, -3.273888069088571e-05, -2.2971551516093314e-05, -1.3592553841590416e-05, -5.824725576530909e-06, -7.105199983925559e-07, 1.0212910410700715e-06, -9.479629738962103e-07, -6.4800224208738655e-06, -1.4989146620791871e-05, -2.5507622922305018e-05, -3.680010559037328e-05, -4.751330925500952e-05, -5.6342996685998514e-05, -6.219760689418763e-05, -6.43381426925771e-05, -6.247627607081085e-05, -5.681790935341269e-05, -4.804570562555455e-05, -3.724175621755421e-05, -2.5759116397239268e-05, -1.5057376003824174e-05, -6.52217704555369e-06, -1.2910204532090575e-06, -1.0716117060383112e-07, -3.2203367936745053e-06, -1.0347490388085134e-05, -2.0699369997601025e-05, -3.3070762583520263e-05, -4.598411760525778e-05, -5.786952533526346e-05, -6.725912680849433e-05, -7.297193224076182e-05, -7.426577212754637e-05, -7.093703607097268e-05, -6.335462239803746e-05, -5.242308179731481e-05, -3.947830555262044e-05, -2.6127641831408255e-05, -1.40536722028628e-05, -4.805415755981812e-06, 3.970754107740504e-07, 8.201573677979468e-07, -3.684177272589295e-06, -1.265059836441651e-05, -2.5048842871910892e-05, -3.940337410313077e-05, -5.3970488806953654e-05, -6.695160118397325e-05, -7.671682396903634e-05, -8.201078890124336e-05, -8.211508975364268e-05, -7.694614760112017e-05, -6.70754598104395e-05, -5.3668311011279e-05, -3.8347599911503494e-05, -2.2998370695859194e-05, -9.536703146295622e-06, 3.288004961632396e-07, 5.31330579178757e-06, 4.722448011307279e-06, -1.4520926470140694e-06, -1.2521142707555555e-05, -2.7173422495252453e-05, -4.362966865301132e-05, -5.9857451560674235e-05, -7.382081093965098e-05, -8.37340485304594e-05, -8.828812860883772e-05, -8.682102634338662e-05, -7.940985233290121e-05, -6.68722641421482e-05, -5.067545862402767e-05, -3.276281859143637e-05, -1.5318684745579958e-05, -4.995179097022628e-07, 9.835378477873746e-06, 1.4360043678607326e-05, 1.2455002433853224e-05, 4.294845439289929e-06, -9.161917660094332e-06, -2.6280911697540432e-05, -4.494579479796812e-05, -6.281505920924246e-05, -7.761065353406593e-05, -8.740282646613196e-05, -9.085574129130691e-05, -8.740246994420886e-05, -7.732673111604527e-05, -6.173975998535752e-05, -4.245358650223352e-05, -2.176521775254514e-05, -2.177275746362284e-06, 1.3911027053836733e-05, 2.4504375687683932e-05, 2.8265772925806232e-05, 2.4692499209777452e-05, 1.4190572073857766e-05, -1.963034719665302e-06, -2.1767242287751287e-05, -4.273606464266777e-05, -6.220158684300259e-05, -7.764389010844752e-05, -8.700711623532698e-05, -8.896212966646999e-05, -8.308226824738085e-05, -6.990903057157993e-05, -5.0898048357339576e-05, -2.8250391551409848e-05, -4.648591584555106e-06, 1.7070939065888524e-05, 3.426919283811003e-05, 4.483610246097669e-05, 4.746067861560732e-05, 4.1805324144661427e-05, 2.8561164072016254e-05, 9.376047273690347e-06, -1.3337763448362239e-05, -3.669369107228704e-05, -5.768403207184747e-05, -7.355299749178812e-05, -8.214345143642277e-05, -8.217372669605538e-05, -7.340908632613719e-05, -5.6705081078689545e-05, -3.3915657695615664e-05, -7.675565029785503e-06, 1.891730607894715e-05, 4.2681644117692485e-05, 6.074785778764635e-05, 7.091963925631717e-05, 7.195647049229592e-05, 6.374084478011355e-05, 4.730774890049361e-05, 2.4731001758482307e-05, -1.1213272728127777e-06, -2.6933674234896898e-05, -4.935004108119756e-05, -6.539146124850959e-05, -7.283194281626493e-05, -7.048564293654636e-05, -5.836808850290254e-05, -3.7710025935666636e-05, -1.0819974704645574e-05, 1.9189215890946798e-05, 4.877753963228315e-05, 7.441309571731836e-05, 9.301200043410063e-05, 0.00010232820204691961, 0.00010124392429133877, 8.992338553071022e-05, 6.980883335927501e-05, 4.345730121713132e-05, 1.4236529750633053e-05, -1.4084065696806647e-05, -3.7797602999489754e-05, -5.372214945964515e-05, -5.960359703749418e-05, -5.4408166761277243e-05, -3.8466670957859606e-05, -1.3450612641463522e-05, 1.7818869309849106e-05, 5.1707706006709486e-05, 8.421106031164527e-05, 0.00011144718155264854, 0.00013014224532525986, 0.00013804550690110773, 0.00013422226766124368, 0.00011918671953026205, 9.485601913183928e-05, 6.43290113657713e-05, 3.151525015709922e-05, 6.582563401025254e-07, -2.418857184238732e-05, -3.9668975659878924e-05, -4.355028067948297e-05, -3.501528044580482e-05, -1.478147714806255e-05, 1.4969278709031641e-05, 5.0844297220464796e-05, 8.864743722369894e-05, 0.00012389149924274534, 0.00015235316823236644, 0.00017060182290151715, 0.00017643622413743287, 0.00016917345055844635, 0.00014975227531976998, 0.00012063605390721932, 8.552454528398812e-05, 4.89084268338047e-05, 1.551983405079227e-05, -1.025368237606017e-05, -2.491943996574264e-05, -2.6325154976802878e-05, -1.3942983969172928e-05, 1.1045215615013149e-05, 4.5874392526457086e-05, 8.652139513287693e-05, 0.0001281905424548313, 0.00016590114682912827, 0.00019510506535880268, 0.000212257873499766, 0.00021527161879930645, 0.00020379218040034175, 0.00017926355940289795, 0.00014476959768217057, 0.00010466950334375724, 6.40704165562056e-05, 2.8200674933032133e-05, 1.760539589668042e-06, -1.1668869774439372e-05, -1.0084417226607911e-05, 6.671248684142483e-06, 3.6868445022264495e-05, 7.708354678470641e-05, 0.00012260513904038817, 0.00016800516459625214, 0.00020780586055479944, 0.0002371607261011377, 0.0002524647570680827, 0.00025181734235957265, 0.00023527834855485708, 0.0002048832830041647, 0.00016441283514723182, 0.00011894255294464529, 7.422614726237953e-05, 3.598750481614843e-05, 9.208086339640431e-06, -2.5013539470819524e-06, 2.6342570436099777e-06, 2.4312426830874756e-05, 6.016694169375114e-05, 0.00010603863483993337, 0.0001564723061164841, 0.00020538060925900936, 0.00024679399211890996, 0.0002756045723799616, 0.00028821147861890495, 0.00028298539109528065, 0.00026049374719150364, 0.00022345469915308058, 0.00017642324382904917, 0.0001252451620530337, 7.634439680259675e-05, 3.5930268495576456e-05, 9.222742846759502e-06, -2.0805683220714855e-07, 9.09559184947284e-06, 3.6274042940931395e-05, 7.823129999451339e-05, 0.000129995183669962, 0.0001853147696238011, 0.00023742376652080566, 0.00027987617067992687, 0.00030735161271877587, 0.0003163293586112559, 0.0003055463021155447, 0.0002761784999165684, 0.000231722166063264, 0.00017758391913957894, 0.00012042957678204402, 6.73687900416553e-05, 2.5075616576941684e-05, -1.0463346598044154e-06, -7.549877864221344e-06, 6.605607268284075e-06, 3.989845572505146e-05, 8.840597729431465e-05, 0.00014626614574808627, 0.00020638543355744332, 0.0002613075776025653, 0.000304136861814186, 0.0003294017515145242, 0.00033375044586136937, 0.00031639085500501096, 0.00027921644505113363, 0.0002265997463837266, 0.00016487529501318932, 0.00010157282667933032, 4.4493914174381644e-05, 7.445481742252014e-07, -2.4155880964826792e-05, -2.6977964807883836e-05, -7.208329861896345e-06, 3.285748971393332e-05, 8.837052155286074e-05, 0.00015250408614519984, 0.0002172815438825637, 0.0002745560195762664, 0.0003170213312841952, 0.0003391295322217047, 0.0003377991379238665, 0.00031282458803616464, 0.0002669317473191768, 0.00020547027816064656, 0.0001357757719233632, 6.627875700360164e-05, 5.467898972710827e-06, -3.916480636689812e-05, -6.206599937286228e-05, -6.0331742133712396e-05, -3.409626879147254e-05, 1.3452914572553709e-05, 7.643946446478367e-05, 0.00014700072642881423, 0.00021624460350722075, 0.00027534429682418704, 0.00031663646223023534, 0.000334585813106969, 0.0003264955885242671, 0.000292872020509094, 0.00023739453172311187, 0.00016649119788780808, 8.856791100697592e-05, 1.2983781743969303e-05, -5.1102571887895465e-05, -9.587358363205567e-05, -0.00011583837476791814, -0.00010853925050469115, -7.488824485335499e-05, -1.908831654873211e-05, 5.18555571034085e-05, 0.00012897847045678645, 0.00020245014457032084, 0.0002627879148349166, 0.0003020393487531692, 0.0003147860406897962, 0.00029884325340390205, 0.0002555640821810812, 0.00018970732344314456, 0.00010888042015722021, 2.262270027131308e-05, -5.876085924683139e-05, -0.0001254727249033749, -0.00016944576054811478, -0.00018536337302066386, -0.00017134801601059735, -0.0001292290398851037, -6.43526145722717e-05, 1.5047636225062888e-05, 9.884504834190011e-05, 0.00017625973850954324, 0.00023719199816696346, 0.0002734844165388495, 0.00027995521668344736, 0.00025507216923870146, 0.00020117922395002097, 0.00012424407759681344, 3.3152333344332874e-05, -6.136770389275625e-05, -0.00014806012040935457, -0.0002165350306313485, -0.0002585683832876384, -0.00026914553018286824, -0.00024711593869142234, -0.00019537452317308635, -0.00012054145918227732, -3.217616176698357e-05, 5.838189827045426e-05, 0.00013940507778897882, 0.00020023129764012992, 0.00023259966110344976, 0.00023170078929979354, 0.00019680827972479165, 0.00013140922237653285, 4.281193105271086e-05, -5.872470501344651e-05, -0.00016123733075801283, -0.0002525280578993261, -0.0003216781187802553, -0.00036041688872501254, -0.0003641754447016865, -0.00033269028062932193, -0.0002700775221455842, -0.00018436400569044054, -8.652749238535762e-05, 1.0839101378223859e-05, 9.50770263443701e-05, 0.00015503427130170166, 0.00018246589752379805, 0.00017308694077655673, 0.0001271429646294564, 4.942337909596972e-05, -5.128989869263023e-05, -0.0001632752682780847, -0.00027329957811161876, -0.0003682479145936668, -0.0004367541987448931, -0.0004706301842816174, -0.0004659131809603423, -0.00042339874198660254, -0.00034858702565543354, -0.0002510441408958286, -0.00014325225492939353, -3.908612416125834e-05, 4.789771992363967e-05, 0.0001061485891113989, 0.00012757605873048306, 0.00010858816676773131, 5.0580569222802296e-05, -4.018950858153403e-05, -0.00015333453484345227, -0.00027558807050809264, -0.0003924258635379374, -0.0004898582701571286, -0.0005561733851209283, -0.0005834137555211782, -0.0005683998460881412, -0.0005131702637299895, -0.0004247774195391685, -0.00031445795320905745, -0.00019627610163297504, -8.540257840650156e-05, 3.76006892111036e-06, 5.9374189731897786e-05, 7.366190402535722e-05, 4.390957474242896e-05, -2.714753100008238e-05, -0.00013161406968720257, -0.00025736718089319766, -0.00038952307659201324, -0.0005122602451592684, -0.0006107761291787028, -0.0006731355097144842, -0.0006917798309586942, -0.00066450668964535, -0.0005947928875684738, -0.0004914152668789029, -0.00036740899668075144, -0.00023848767159506679, -0.00012111571413697675, -3.0469778721453622e-05, 2.1458750779856928e-05, 2.738302828220185e-05, -1.4330453268485144e-05, -9.940662857843563e-05, -0.00021813830244354904, -0.0003565419465303421, -0.0004980552475899458, -0.0006255707703530788, -0.0007235559169203043, -0.0007799969171173871, -0.0007879231707192957, -0.0007463193614967167, -0.0006603061337955296, -0.000540559645742178, -0.0004020363849122077, -0.000262153975199908, -0.000138650051667355, -4.738142524729483e-05, -3.3716469260980375e-07, -4.1137723201245535e-06, -5.904650970478542e-05, -0.00015911052469164133, -0.00029261125018820167, -0.0004435853043105453, -0.0005937444511801004, -0.0007247260073199868, -0.0008203731849789619, -0.0008687615627422929, -0.0008637187420390546, -0.0008056431543081999, -0.0007015132578089833, -0.0005640813033096492, -0.00041034031892195344, -0.00025945197558030486, -0.00013038606266491115, -3.956211367039941e-05, 1.2132056781410938e-06, -1.374565817968687e-05, -8.324159716721624e-05, -0.00019928136316593736, -0.0003480071609374136, -0.0005113648949190974, -0.0006693089380860329, -0.0008022735128179193, -0.0008936077356338501, -0.0009316694922745228, -0.0009113160776905715, -0.0008346016984432936, -0.0007105859112925828, -0.000554271973669529, -0.0003847957996185869, -0.00022308625921141356, -8.928171155275777e-05, -2.215039103248273e-07, 3.2675165130058303e-05, 4.876009370491374e-06, -8.063978748396039e-05, -0.0002136844996130094, -0.0003780627448577434, -0.000553529302123934, -0.0007182674598880112, -0.0008515846566297114, -0.0009364920551888645, -0.0009618479525670409, -0.0009237928315997124, -0.0008262943592853844, -0.0006807227618992329, -0.0005045056459493935, -0.00031901613692753017, -0.00014695427671540529, -9.538789527141489e-06, 7.614109927089885e-05, 9.928485815180466e-05, 5.6777720601530746e-05, -4.6354278310900554e-05, -0.00019749645434785634, -0.00037794484524056315, -0.0005651753745041788, -0.0007356071146205068, -0.0008675219723954797, -0.0009437777334824204, -0.0009539778111502528, -0.0008958217804320157, -0.0007754624239169061, -0.0006068166112527251, -0.0004099045763723552, -0.00020841805962845683, -2.6810252165887505e-05, 0.000112734611320775, 0.00019307606271468103, 0.00020429061260074377, 0.00014496753283310682, 2.2459013052866794e-05, -0.0001479557977290824, -0.0003448986099101603, -0.0005434933118522167, -0.0007184246205724776, -0.0008470779284834862, -0.0009123713825829327, -0.0009049262735061347, -0.0008242988842539489, -0.000679114309605211, -0.000486074888613075, -0.00026795684243552387, -5.0835202273447067e-05, 0.0001391253317706287, 0.0002789188292808831, 0.00035158268292434514, 0.0003483569889795035, 0.00026984408032149076, 0.0001260158169316128, -6.494308036053553e-05, -0.0002788211568258703, -0.000488334393594414, -0.0006664874381385744, -0.0007899285992607474, -0.0008418817888014019, -0.0008142869337461889, -0.0007088779238983989, -0.0005370522267185152, -0.0003185406676493585, -7.902989455033094e-05, 0.00015297500067390501, 0.00034966558450832963, 0.000487389275804162, 0.0005496226949617267, 0.0005290855187922716, 0.00042872512130998075, 0.00026143985451199114, 4.85639029648155e-05, -0.00018270824512001127, -0.0004026478563901037, -0.0005826616543345153, -0.0006988524692133069, -0.0007350277155637741, -0.0006847776821814477, -0.0005523570580407977, -0.00035224956809543073, -0.00010745918552856892, 0.00015327213623095304, 0.0003989831020589918, 0.0006003181915730238, 0.0007331866072490811, 0.0007817996665835381, 0.0007407031953334808, 0.0006155451410450041, 0.0004224706208333373, 0.00018620853370521218, -6.292436592048034e-05, -0.0002927396271843463, -0.0004731577355414629, -0.0005799620994366705, -0.0005978570552542806, -0.0005224458873271942, -0.00036087134503759444, -0.00013103037781547755, 0.00014055446081329137, 0.00042195271817035973, 0.0006797434762120247, 0.0008831517188809812, 0.0010078931227326393, 0.0010392452822998166, 0.0009739593951962888, 0.0008207634673453867, 0.0005993829690851271, 0.00033818729571066797, 7.074230234138668e-05, -0.0001683123700786382, -0.00034755546948872507, -0.000442714081145823, -0.000439740571891889, -0.0003366463934071362, -0.00014385490794666111, 0.00011698386515490711, 0.00041558302473276854, 0.0007167037110775709, 0.0009844867745414376, 0.0011868998408317566, 0.001299747615121305, 0.0013097451301291585, 0.0012162617640569806, 0.0010315111139789224, 0.0007791459211148322, 0.0004914217279292643, 0.00020526650769170374, -4.2263607610948384e-05, -0.00021858508989680558, -0.0002996722178068012, -0.0002731161075644195, -0.00013976774062030017, 8.625064947409555e-05, 0.00037918201996944845, 0.0007047299877740443, 0.001024241792038083, 0.001299469149671495, 0.00149732013233006, 0.0015940143493935466, 0.001578116207383573, 0.0014520635595545173, 0.0012319879606366158, 0.0009458310669288039, 0.0006299798842519522, 0.0003248223219998181, 6.976782606216148e-05, -0.00010165544517803937, -0.00016601593233644962, -0.0001129779702750966, 5.329848136170767e-05, 0.00031454546842724085, 0.0006405299645848572, 0.0009927010396495461, 0.0013289027847349644, 0.001608576043508947, 0.0017978082178160548, 0.00187360355630517, 0.0018268339335918427, 0.0016634969506412745, 0.001404103939421475, 0.0010812632972374558, 0.0007357386057265103, 0.0004114595940336585, 0.00015009490016382188, -1.4141868632577825e-05, -5.880769822397269e-05, 2.3877373678260483e-05, 0.0002259325556224212, 0.0005244656931608915, 0.0008843814721331, 0.0012626294046640396, 0.0016134774778038263, 0.0018941661110147834, 0.0020702441688627005, 0.0021199204493314028, 0.0020368839614093304, 0.001831226167269051, 0.0015283356187865138, 0.0011658834991976619, 0.0007892563007771969, 0.0004459894844330847, 0.00017988463514484465, 2.5535773602314293e-05, 3.950308837374905e-06, 0.00011981668649241328, 0.0003607736434787512, 0.0006987896631471813, 0.0010935006430372596, 0.001497109537012875, 0.001860252465121448, 0.0021381149999797344, 0.00229603610932827, 0.0023139058612287045, 0.002188795944675803, 0.0019354780670255423, 0.0015847544418647885, 0.001179777435027063, 0.0007708062184974551, 0.00040902968612499535, 0.0001402190828230232, -1.0060381328003132e-06, 4.419985543790972e-06, 0.00015749747399240732, 0.0004408697132021189, 0.0008208077633753419, 0.0012512466637417674, 0.0016793909016996622, 0.0020522065460681915, 0.0023230058141052723, 0.002457301365211606, 0.0024372038897126913, 0.002263797679916024, 0.001957182539626956, 0.0015541559550911188, 0.0011038011871278286, 0.0006615051534026861, 0.0002821406815201044, 1.3247488823253661e-05, -0.00011094095680164173, -7.387413643300533e-05, 0.00012109281669836491, 0.0004509271529968828, 0.0008755919989198446, 0.0013428565580397844, 0.0017946658190339804, 0.0021742943208664656, 0.002433402929455042, 0.0025381208397448063, 0.002473390894010663, 0.0022450177930295467, 0.0018791476031765342, 0.0014192172093316913, 0.0009207240073010325, 0.0004444514634087682, 4.897124381386675e-05, -0.00021665218810085207, -0.00031904669594950974, -0.00024482913431711495, -2.4616138034616597e-06, 0.0003785868175327778, 0.0008512949571013451, 0.0013567572459578514, 0.0018313833279535174, 0.0022147484123706818, 0.002457128604874015, 0.0025257812812924385, 0.0024091778323054314, 0.0021186445374041796, 0.0016871824627742171, 0.0011655815178528428, 0.0006162913050502539, 0.00010577965440461412, -0.00030368196894414723, -0.0005617938586510718, -0.0006365947774611413, -0.0005186149501241744, -0.0002222780167357996, 0.00021565065253525972, 0.0007404043572023511, 0.0012858356349170208, 0.0017825162503868341, 0.002166326390579343, 0.0023864731192588806, 0.002411932684481144, 0.0022355064284056425, 0.0018749580485746264, 0.0013710618950426579, 0.0007827765657566488, 0.00018010742496699095, -0.00036447294405661523, -0.0007850013789720833, -0.0010302839800715446, -0.0010704078013077378, -0.0009006776381283998, -0.0005424619885161519, -4.081116640008986e-05, 0.0005408903816714883, 0.001128604169934988, 0.0016467220848426223, 0.0020274408161640167, 0.0022192662581801414, 0.002193583408370614, 0.0019484524382278323, 0.0015091347740963101, 0.0009252466261386871, 0.00026485559646971524, -0.00039377494249492884, -0.00097179802833125, -0.0013995702611282468, -0.0016254024812951684, -0.0016221749829128385, -0.0013909731060266495, -0.0009612601716071367, -0.00038752821274101734, 0.0002571971563156694, 0.0008902240660972893, 0.0014293601270765066, 0.001803128281608224, 0.001959765562787652, 0.0018738715443760157, 0.0015498603461310267, 0.0010217441013082862, 0.00034924165811389685, -0.0003893508401233703, -0.0011066764127463102, -0.0017170667415484786, -0.0021472040098160505, -0.002345368964597583, -0.002288114046677947, -0.001983499154448509, -0.001470454502850771, -0.0008142984588630497, -9.892897651297972e-05, 0.0005833841278217733, 0.0011433652834966779, 0.0015058607095852494, 0.0016193402698263526, 0.0014625805197283626, 0.0010476583847776055, 0.0004188464372418821, -0.0003525030333548784, -0.0011765005765482783, -0.0019556644838303328, -0.0025969420094043016, -0.003023322904482484, -0.003183603286743164, -0.0030590605456382036, -0.0026661758311092854, -0.0020550184417515993, -0.0013034361181780696, -0.0005077252280898392, 0.00022910669213160872, 0.0008100569248199463, 0.0011562571162357926, 0.0012170011177659035, 0.0009764014394022524, 0.00045580402365885675, -0.0002883907873183489, -0.0011712893610820174, -0.002089689252898097, -0.002934666583314538, -0.0036050404887646437, -0.004020043648779392, -0.004129626788198948, -0.003921079449355602, -0.0034210984595119953, -0.0026929916348308325, -0.0018292940221726894, -0.0009406557073816657, -0.00014233279216568917, 0.00046007544733583927, 0.0007838818710297346, 0.0007798994774930179, 0.00043901149183511734, -0.00020614599634427577, -0.001084665535017848, -0.0020956515800207853, -0.0031203434336930513, -0.0040366267785429955, -0.004734165035188198, -0.005128274671733379, -0.005170821212232113, -0.004856716841459274, -0.004225169774144888, -0.003355449065566063, -0.0023576098028570414, -0.0013592590112239122, -0.0004899511695839465, 0.00013488966214936227, 0.00042852669139392674, 0.0003441201406531036, -0.00011885302956216037, -0.0009138369932770729, -0.0019522723741829395, -0.003113965969532728, -0.0042615486308932304, -0.005257286597043276, -0.005980201065540314, -0.006341366562992334, -0.0062954663299024105, -0.005847118329256773, -0.005051084794104099, -0.004006269387900829, -0.0028441245667636395, -0.0017128356266766787, -0.0007591656758449972, -0.00011018584336852655, 0.00014285002544056624, -4.355455166660249e-05, -0.0006589325494132936, -0.0016392478719353676, -0.002873950405046344, -0.0042189303785562515, -0.005513859912753105, -0.006601848639547825, -0.007349013816565275, -0.007661526091396809, -0.007497986778616905, -0.006875504739582539, -0.005868617910891771, -0.0046010552905499935, -0.0032312474213540554, -0.0019332576775923371, -0.000875424942933023, -0.00019932146824430674, -1.6458841400890378e-06, -0.0003213492745999247, -0.0011336912866681814, -0.002352093579247594, -0.003837710013613105, -0.005415673367679119, -0.006896132603287697, -0.008097565732896328, -0.008869522251188755, -0.00911195669323206, -0.008788700215518475, -0.007933270186185837, -0.006646143272519112, -0.0050836591981351376, -0.003439759835600853, -0.0019226653967052698, -0.0007292884984053671, -2.0496958313742653e-05, 9.968208178179339e-05, -0.00040174112655222416, -0.0014810278080403805, -0.0030214176513254642, -0.004845982883125544, -0.006738244090229273, -0.008468170650303364, -0.009820466861128807, -0.010621694847941399, -0.010762847028672695, -0.010214464738965034, -0.009032259695231915, -0.0073522948659956455, -0.005376087035983801, -0.003347215009853244, -0.0015221136854961514, -0.00013852499250788242, 0.0006145504303276539, 0.0006216498441062868, -0.00014281447511166334, -0.00160891842097044, -0.003617275273427367, -0.005936339497566223, -0.008289135061204433, -0.010386369191110134, -0.011962021701037884, -0.012807088904082775, -0.01279725693166256, -0.011910917237401009, -0.010235018096864223, -0.00795766245573759, -0.005347947124391794, -0.002725165570154786, -0.00042080218554474413, 0.0012622118229046464, 0.002088060835376382, 0.0019196112407371402, 0.0007388632511720061, -0.0013465944211930037, -0.004112401977181435, -0.007240965962409973, -0.010357349179685116, -0.013073553331196308, -0.015036078169941902, -0.01597105897963047, -0.015721360221505165, -0.014270796440541744, -0.011752014979720116, -0.008436424657702446, -0.0047066910192370415, -0.0010144042316824198, 0.0021725285332649946, 0.004426843952387571, 0.005416504107415676, 0.004950197413563728, 0.003007848747074604, -0.00024822360137477517, -0.004483760334551334, -0.009224393405020237, -0.013906087726354599, -0.017939096316695213, -0.020778490230441093, -0.02199321798980236, -0.021325482055544853, -0.018732866272330284, -0.014407365582883358, -0.008767803199589252, -0.002424986567348242, 0.0038779007736593485, 0.009344316087663174, 0.013214901089668274, 0.014860034920275211, 0.013864146545529366, 0.010091964155435562, 0.0037283895071595907, -0.004713867790997028, -0.014421510510146618, -0.024341752752661705, -0.03327265381813049, -0.03997476026415825, -0.0432935506105423, -0.04228069260716438, -0.0363016277551651, -0.025118259713053703, -0.008937237784266472, 0.011581993661820889, 0.035361792892217636, 0.060981448739767075, 0.08678679168224335, 0.11102475225925446, 0.1319904327392578, 0.1481732875108719, 0.15838825702667236, 0.1618797332048416, 0.15838825702667236, 0.1481732875108719, 0.1319904327392578, 0.11102475225925446, 0.08678679168224335, 0.060981448739767075, 0.035361792892217636, 0.011581993661820889, -0.008937237784266472, -0.025118259713053703, -0.0363016277551651, -0.04228069260716438, -0.0432935506105423, -0.03997476026415825, -0.03327265381813049, -0.024341752752661705, -0.014421510510146618, -0.004713867790997028, 0.0037283895071595907, 0.010091964155435562, 0.013864146545529366, 0.014860034920275211, 0.013214901089668274, 0.009344316087663174, 0.0038779007736593485, -0.002424986567348242, -0.008767803199589252, -0.014407365582883358, -0.018732866272330284, -0.021325482055544853, -0.02199321798980236, -0.020778490230441093, -0.017939096316695213, -0.013906087726354599, -0.009224393405020237, -0.004483760334551334, -0.00024822360137477517, 0.003007848747074604, 0.004950197413563728, 0.005416504107415676, 0.004426843952387571, 0.0021725285332649946, -0.0010144042316824198, -0.0047066910192370415, -0.008436424657702446, -0.011752014979720116, -0.014270796440541744, -0.015721360221505165, -0.01597105897963047, -0.015036078169941902, -0.013073553331196308, -0.010357349179685116, -0.007240965962409973, -0.004112401977181435, -0.0013465944211930037, 0.0007388632511720061, 0.0019196112407371402, 0.002088060835376382, 0.0012622118229046464, -0.00042080218554474413, -0.002725165570154786, -0.005347947124391794, -0.00795766245573759, -0.010235018096864223, -0.011910917237401009, -0.01279725693166256, -0.012807088904082775, -0.011962021701037884, -0.010386369191110134, -0.008289135061204433, -0.005936339497566223, -0.003617275273427367, -0.00160891842097044, -0.00014281447511166334, 0.0006216498441062868, 0.0006145504303276539, -0.00013852499250788242, -0.0015221136854961514, -0.003347215009853244, -0.005376087035983801, -0.0073522948659956455, -0.009032259695231915, -0.010214464738965034, -0.010762847028672695, -0.010621694847941399, -0.009820466861128807, -0.008468170650303364, -0.006738244090229273, -0.004845982883125544, -0.0030214176513254642, -0.0014810278080403805, -0.00040174112655222416, 9.968208178179339e-05, -2.0496958313742653e-05, -0.0007292884984053671, -0.0019226653967052698, -0.003439759835600853, -0.0050836591981351376, -0.006646143272519112, -0.007933270186185837, -0.008788700215518475, -0.00911195669323206, -0.008869522251188755, -0.008097565732896328, -0.006896132603287697, -0.005415673367679119, -0.003837710013613105, -0.002352093579247594, -0.0011336912866681814, -0.0003213492745999247, -1.6458841400890378e-06, -0.00019932146824430674, -0.000875424942933023, -0.0019332576775923371, -0.0032312474213540554, -0.0046010552905499935, -0.005868617910891771, -0.006875504739582539, -0.007497986778616905, -0.007661526091396809, -0.007349013816565275, -0.006601848639547825, -0.005513859912753105, -0.0042189303785562515, -0.002873950405046344, -0.0016392478719353676, -0.0006589325494132936, -4.355455166660249e-05, 0.00014285002544056624, -0.00011018584336852655, -0.0007591656758449972, -0.0017128356266766787, -0.0028441245667636395, -0.004006269387900829, -0.005051084794104099, -0.005847118329256773, -0.0062954663299024105, -0.006341366562992334, -0.005980201065540314, -0.005257286597043276, -0.0042615486308932304, -0.003113965969532728, -0.0019522723741829395, -0.0009138369932770729, -0.00011885302956216037, 0.0003441201406531036, 0.00042852669139392674, 0.00013488966214936227, -0.0004899511695839465, -0.0013592590112239122, -0.0023576098028570414, -0.003355449065566063, -0.004225169774144888, -0.004856716841459274, -0.005170821212232113, -0.005128274671733379, -0.004734165035188198, -0.0040366267785429955, -0.0031203434336930513, -0.0020956515800207853, -0.001084665535017848, -0.00020614599634427577, 0.00043901149183511734, 0.0007798994774930179, 0.0007838818710297346, 0.00046007544733583927, -0.00014233279216568917, -0.0009406557073816657, -0.0018292940221726894, -0.0026929916348308325, -0.0034210984595119953, -0.003921079449355602, -0.004129626788198948, -0.004020043648779392, -0.0036050404887646437, -0.002934666583314538, -0.002089689252898097, -0.0011712893610820174, -0.0002883907873183489, 0.00045580402365885675, 0.0009764014394022524, 0.0012170011177659035, 0.0011562571162357926, 0.0008100569248199463, 0.00022910669213160872, -0.0005077252280898392, -0.0013034361181780696, -0.0020550184417515993, -0.0026661758311092854, -0.0030590605456382036, -0.003183603286743164, -0.003023322904482484, -0.0025969420094043016, -0.0019556644838303328, -0.0011765005765482783, -0.0003525030333548784, 0.0004188464372418821, 0.0010476583847776055, 0.0014625805197283626, 0.0016193402698263526, 0.0015058607095852494, 0.0011433652834966779, 0.0005833841278217733, -9.892897651297972e-05, -0.0008142984588630497, -0.001470454502850771, -0.001983499154448509, -0.002288114046677947, -0.002345368964597583, -0.0021472040098160505, -0.0017170667415484786, -0.0011066764127463102, -0.0003893508401233703, 0.00034924165811389685, 0.0010217441013082862, 0.0015498603461310267, 0.0018738715443760157, 0.001959765562787652, 0.001803128281608224, 0.0014293601270765066, 0.0008902240660972893, 0.0002571971563156694, -0.00038752821274101734, -0.0009612601716071367, -0.0013909731060266495, -0.0016221749829128385, -0.0016254024812951684, -0.0013995702611282468, -0.00097179802833125, -0.00039377494249492884, 0.00026485559646971524, 0.0009252466261386871, 0.0015091347740963101, 0.0019484524382278323, 0.002193583408370614, 0.0022192662581801414, 0.0020274408161640167, 0.0016467220848426223, 0.001128604169934988, 0.0005408903816714883, -4.081116640008986e-05, -0.0005424619885161519, -0.0009006776381283998, -0.0010704078013077378, -0.0010302839800715446, -0.0007850013789720833, -0.00036447294405661523, 0.00018010742496699095, 0.0007827765657566488, 0.0013710618950426579, 0.0018749580485746264, 0.0022355064284056425, 0.002411932684481144, 0.0023864731192588806, 0.002166326390579343, 0.0017825162503868341, 0.0012858356349170208, 0.0007404043572023511, 0.00021565065253525972, -0.0002222780167357996, -0.0005186149501241744, -0.0006365947774611413, -0.0005617938586510718, -0.00030368196894414723, 0.00010577965440461412, 0.0006162913050502539, 0.0011655815178528428, 0.0016871824627742171, 0.0021186445374041796, 0.0024091778323054314, 0.0025257812812924385, 0.002457128604874015, 0.0022147484123706818, 0.0018313833279535174, 0.0013567572459578514, 0.0008512949571013451, 0.0003785868175327778, -2.4616138034616597e-06, -0.00024482913431711495, -0.00031904669594950974, -0.00021665218810085207, 4.897124381386675e-05, 0.0004444514634087682, 0.0009207240073010325, 0.0014192172093316913, 0.0018791476031765342, 0.0022450177930295467, 0.002473390894010663, 0.0025381208397448063, 0.002433402929455042, 0.0021742943208664656, 0.0017946658190339804, 0.0013428565580397844, 0.0008755919989198446, 0.0004509271529968828, 0.00012109281669836491, -7.387413643300533e-05, -0.00011094095680164173, 1.3247488823253661e-05, 0.0002821406815201044, 0.0006615051534026861, 0.0011038011871278286, 0.0015541559550911188, 0.001957182539626956, 0.002263797679916024, 0.0024372038897126913, 0.002457301365211606, 0.0023230058141052723, 0.0020522065460681915, 0.0016793909016996622, 0.0012512466637417674, 0.0008208077633753419, 0.0004408697132021189, 0.00015749747399240732, 4.419985543790972e-06, -1.0060381328003132e-06, 0.0001402190828230232, 0.00040902968612499535, 0.0007708062184974551, 0.001179777435027063, 0.0015847544418647885, 0.0019354780670255423, 0.002188795944675803, 0.0023139058612287045, 0.00229603610932827, 0.0021381149999797344, 0.001860252465121448, 0.001497109537012875, 0.0010935006430372596, 0.0006987896631471813, 0.0003607736434787512, 0.00011981668649241328, 3.950308837374905e-06, 2.5535773602314293e-05, 0.00017988463514484465, 0.0004459894844330847, 0.0007892563007771969, 0.0011658834991976619, 0.0015283356187865138, 0.001831226167269051, 0.0020368839614093304, 0.0021199204493314028, 0.0020702441688627005, 0.0018941661110147834, 0.0016134774778038263, 0.0012626294046640396, 0.0008843814721331, 0.0005244656931608915, 0.0002259325556224212, 2.3877373678260483e-05, -5.880769822397269e-05, -1.4141868632577825e-05, 0.00015009490016382188, 0.0004114595940336585, 0.0007357386057265103, 0.0010812632972374558, 0.001404103939421475, 0.0016634969506412745, 0.0018268339335918427, 0.00187360355630517, 0.0017978082178160548, 0.001608576043508947, 0.0013289027847349644, 0.0009927010396495461, 0.0006405299645848572, 0.00031454546842724085, 5.329848136170767e-05, -0.0001129779702750966, -0.00016601593233644962, -0.00010165544517803937, 6.976782606216148e-05, 0.0003248223219998181, 0.0006299798842519522, 0.0009458310669288039, 0.0012319879606366158, 0.0014520635595545173, 0.001578116207383573, 0.0015940143493935466, 0.00149732013233006, 0.001299469149671495, 0.001024241792038083, 0.0007047299877740443, 0.00037918201996944845, 8.625064947409555e-05, -0.00013976774062030017, -0.0002731161075644195, -0.0002996722178068012, -0.00021858508989680558, -4.2263607610948384e-05, 0.00020526650769170374, 0.0004914217279292643, 0.0007791459211148322, 0.0010315111139789224, 0.0012162617640569806, 0.0013097451301291585, 0.001299747615121305, 0.0011868998408317566, 0.0009844867745414376, 0.0007167037110775709, 0.00041558302473276854, 0.00011698386515490711, -0.00014385490794666111, -0.0003366463934071362, -0.000439740571891889, -0.000442714081145823, -0.00034755546948872507, -0.0001683123700786382, 7.074230234138668e-05, 0.00033818729571066797, 0.0005993829690851271, 0.0008207634673453867, 0.0009739593951962888, 0.0010392452822998166, 0.0010078931227326393, 0.0008831517188809812, 0.0006797434762120247, 0.00042195271817035973, 0.00014055446081329137, -0.00013103037781547755, -0.00036087134503759444, -0.0005224458873271942, -0.0005978570552542806, -0.0005799620994366705, -0.0004731577355414629, -0.0002927396271843463, -6.292436592048034e-05, 0.00018620853370521218, 0.0004224706208333373, 0.0006155451410450041, 0.0007407031953334808, 0.0007817996665835381, 0.0007331866072490811, 0.0006003181915730238, 0.0003989831020589918, 0.00015327213623095304, -0.00010745918552856892, -0.00035224956809543073, -0.0005523570580407977, -0.0006847776821814477, -0.0007350277155637741, -0.0006988524692133069, -0.0005826616543345153, -0.0004026478563901037, -0.00018270824512001127, 4.85639029648155e-05, 0.00026143985451199114, 0.00042872512130998075, 0.0005290855187922716, 0.0005496226949617267, 0.000487389275804162, 0.00034966558450832963, 0.00015297500067390501, -7.902989455033094e-05, -0.0003185406676493585, -0.0005370522267185152, -0.0007088779238983989, -0.0008142869337461889, -0.0008418817888014019, -0.0007899285992607474, -0.0006664874381385744, -0.000488334393594414, -0.0002788211568258703, -6.494308036053553e-05, 0.0001260158169316128, 0.00026984408032149076, 0.0003483569889795035, 0.00035158268292434514, 0.0002789188292808831, 0.0001391253317706287, -5.0835202273447067e-05, -0.00026795684243552387, -0.000486074888613075, -0.000679114309605211, -0.0008242988842539489, -0.0009049262735061347, -0.0009123713825829327, -0.0008470779284834862, -0.0007184246205724776, -0.0005434933118522167, -0.0003448986099101603, -0.0001479557977290824, 2.2459013052866794e-05, 0.00014496753283310682, 0.00020429061260074377, 0.00019307606271468103, 0.000112734611320775, -2.6810252165887505e-05, -0.00020841805962845683, -0.0004099045763723552, -0.0006068166112527251, -0.0007754624239169061, -0.0008958217804320157, -0.0009539778111502528, -0.0009437777334824204, -0.0008675219723954797, -0.0007356071146205068, -0.0005651753745041788, -0.00037794484524056315, -0.00019749645434785634, -4.6354278310900554e-05, 5.6777720601530746e-05, 9.928485815180466e-05, 7.614109927089885e-05, -9.538789527141489e-06, -0.00014695427671540529, -0.00031901613692753017, -0.0005045056459493935, -0.0006807227618992329, -0.0008262943592853844, -0.0009237928315997124, -0.0009618479525670409, -0.0009364920551888645, -0.0008515846566297114, -0.0007182674598880112, -0.000553529302123934, -0.0003780627448577434, -0.0002136844996130094, -8.063978748396039e-05, 4.876009370491374e-06, 3.2675165130058303e-05, -2.215039103248273e-07, -8.928171155275777e-05, -0.00022308625921141356, -0.0003847957996185869, -0.000554271973669529, -0.0007105859112925828, -0.0008346016984432936, -0.0009113160776905715, -0.0009316694922745228, -0.0008936077356338501, -0.0008022735128179193, -0.0006693089380860329, -0.0005113648949190974, -0.0003480071609374136, -0.00019928136316593736, -8.324159716721624e-05, -1.374565817968687e-05, 1.2132056781410938e-06, -3.956211367039941e-05, -0.00013038606266491115, -0.00025945197558030486, -0.00041034031892195344, -0.0005640813033096492, -0.0007015132578089833, -0.0008056431543081999, -0.0008637187420390546, -0.0008687615627422929, -0.0008203731849789619, -0.0007247260073199868, -0.0005937444511801004, -0.0004435853043105453, -0.00029261125018820167, -0.00015911052469164133, -5.904650970478542e-05, -4.1137723201245535e-06, -3.3716469260980375e-07, -4.738142524729483e-05, -0.000138650051667355, -0.000262153975199908, -0.0004020363849122077, -0.000540559645742178, -0.0006603061337955296, -0.0007463193614967167, -0.0007879231707192957, -0.0007799969171173871, -0.0007235559169203043, -0.0006255707703530788, -0.0004980552475899458, -0.0003565419465303421, -0.00021813830244354904, -9.940662857843563e-05, -1.4330453268485144e-05, 2.738302828220185e-05, 2.1458750779856928e-05, -3.0469778721453622e-05, -0.00012111571413697675, -0.00023848767159506679, -0.00036740899668075144, -0.0004914152668789029, -0.0005947928875684738, -0.00066450668964535, -0.0006917798309586942, -0.0006731355097144842, -0.0006107761291787028, -0.0005122602451592684, -0.00038952307659201324, -0.00025736718089319766, -0.00013161406968720257, -2.714753100008238e-05, 4.390957474242896e-05, 7.366190402535722e-05, 5.9374189731897786e-05, 3.76006892111036e-06, -8.540257840650156e-05, -0.00019627610163297504, -0.00031445795320905745, -0.0004247774195391685, -0.0005131702637299895, -0.0005683998460881412, -0.0005834137555211782, -0.0005561733851209283, -0.0004898582701571286, -0.0003924258635379374, -0.00027558807050809264, -0.00015333453484345227, -4.018950858153403e-05, 5.0580569222802296e-05, 0.00010858816676773131, 0.00012757605873048306, 0.0001061485891113989, 4.789771992363967e-05, -3.908612416125834e-05, -0.00014325225492939353, -0.0002510441408958286, -0.00034858702565543354, -0.00042339874198660254, -0.0004659131809603423, -0.0004706301842816174, -0.0004367541987448931, -0.0003682479145936668, -0.00027329957811161876, -0.0001632752682780847, -5.128989869263023e-05, 4.942337909596972e-05, 0.0001271429646294564, 0.00017308694077655673, 0.00018246589752379805, 0.00015503427130170166, 9.50770263443701e-05, 1.0839101378223859e-05, -8.652749238535762e-05, -0.00018436400569044054, -0.0002700775221455842, -0.00033269028062932193, -0.0003641754447016865, -0.00036041688872501254, -0.0003216781187802553, -0.0002525280578993261, -0.00016123733075801283, -5.872470501344651e-05, 4.281193105271086e-05, 0.00013140922237653285, 0.00019680827972479165, 0.00023170078929979354, 0.00023259966110344976, 0.00020023129764012992, 0.00013940507778897882, 5.838189827045426e-05, -3.217616176698357e-05, -0.00012054145918227732, -0.00019537452317308635, -0.00024711593869142234, -0.00026914553018286824, -0.0002585683832876384, -0.0002165350306313485, -0.00014806012040935457, -6.136770389275625e-05, 3.3152333344332874e-05, 0.00012424407759681344, 0.00020117922395002097, 0.00025507216923870146, 0.00027995521668344736, 0.0002734844165388495, 0.00023719199816696346, 0.00017625973850954324, 9.884504834190011e-05, 1.5047636225062888e-05, -6.43526145722717e-05, -0.0001292290398851037, -0.00017134801601059735, -0.00018536337302066386, -0.00016944576054811478, -0.0001254727249033749, -5.876085924683139e-05, 2.262270027131308e-05, 0.00010888042015722021, 0.00018970732344314456, 0.0002555640821810812, 0.00029884325340390205, 0.0003147860406897962, 0.0003020393487531692, 0.0002627879148349166, 0.00020245014457032084, 0.00012897847045678645, 5.18555571034085e-05, -1.908831654873211e-05, -7.488824485335499e-05, -0.00010853925050469115, -0.00011583837476791814, -9.587358363205567e-05, -5.1102571887895465e-05, 1.2983781743969303e-05, 8.856791100697592e-05, 0.00016649119788780808, 0.00023739453172311187, 0.000292872020509094, 0.0003264955885242671, 0.000334585813106969, 0.00031663646223023534, 0.00027534429682418704, 0.00021624460350722075, 0.00014700072642881423, 7.643946446478367e-05, 1.3452914572553709e-05, -3.409626879147254e-05, -6.0331742133712396e-05, -6.206599937286228e-05, -3.916480636689812e-05, 5.467898972710827e-06, 6.627875700360164e-05, 0.0001357757719233632, 0.00020547027816064656, 0.0002669317473191768, 0.00031282458803616464, 0.0003377991379238665, 0.0003391295322217047, 0.0003170213312841952, 0.0002745560195762664, 0.0002172815438825637, 0.00015250408614519984, 8.837052155286074e-05, 3.285748971393332e-05, -7.208329861896345e-06, -2.6977964807883836e-05, -2.4155880964826792e-05, 7.445481742252014e-07, 4.4493914174381644e-05, 0.00010157282667933032, 0.00016487529501318932, 0.0002265997463837266, 0.00027921644505113363, 0.00031639085500501096, 0.00033375044586136937, 0.0003294017515145242, 0.000304136861814186, 0.0002613075776025653, 0.00020638543355744332, 0.00014626614574808627, 8.840597729431465e-05, 3.989845572505146e-05, 6.605607268284075e-06, -7.549877864221344e-06, -1.0463346598044154e-06, 2.5075616576941684e-05, 6.73687900416553e-05, 0.00012042957678204402, 0.00017758391913957894, 0.000231722166063264, 0.0002761784999165684, 0.0003055463021155447, 0.0003163293586112559, 0.00030735161271877587, 0.00027987617067992687, 0.00023742376652080566, 0.0001853147696238011, 0.000129995183669962, 7.823129999451339e-05, 3.6274042940931395e-05, 9.09559184947284e-06, -2.0805683220714855e-07, 9.222742846759502e-06, 3.5930268495576456e-05, 7.634439680259675e-05, 0.0001252451620530337, 0.00017642324382904917, 0.00022345469915308058, 0.00026049374719150364, 0.00028298539109528065, 0.00028821147861890495, 0.0002756045723799616, 0.00024679399211890996, 0.00020538060925900936, 0.0001564723061164841, 0.00010603863483993337, 6.016694169375114e-05, 2.4312426830874756e-05, 2.6342570436099777e-06, -2.5013539470819524e-06, 9.208086339640431e-06, 3.598750481614843e-05, 7.422614726237953e-05, 0.00011894255294464529, 0.00016441283514723182, 0.0002048832830041647, 0.00023527834855485708, 0.00025181734235957265, 0.0002524647570680827, 0.0002371607261011377, 0.00020780586055479944, 0.00016800516459625214, 0.00012260513904038817, 7.708354678470641e-05, 3.6868445022264495e-05, 6.671248684142483e-06, -1.0084417226607911e-05, -1.1668869774439372e-05, 1.760539589668042e-06, 2.8200674933032133e-05, 6.40704165562056e-05, 0.00010466950334375724, 0.00014476959768217057, 0.00017926355940289795, 0.00020379218040034175, 0.00021527161879930645, 0.000212257873499766, 0.00019510506535880268, 0.00016590114682912827, 0.0001281905424548313, 8.652139513287693e-05, 4.5874392526457086e-05, 1.1045215615013149e-05, -1.3942983969172928e-05, -2.6325154976802878e-05, -2.491943996574264e-05, -1.025368237606017e-05, 1.551983405079227e-05, 4.89084268338047e-05, 8.552454528398812e-05, 0.00012063605390721932, 0.00014975227531976998, 0.00016917345055844635, 0.00017643622413743287, 0.00017060182290151715, 0.00015235316823236644, 0.00012389149924274534, 8.864743722369894e-05, 5.0844297220464796e-05, 1.4969278709031641e-05, -1.478147714806255e-05, -3.501528044580482e-05, -4.355028067948297e-05, -3.9668975659878924e-05, -2.418857184238732e-05, 6.582563401025254e-07, 3.151525015709922e-05, 6.43290113657713e-05, 9.485601913183928e-05, 0.00011918671953026205, 0.00013422226766124368, 0.00013804550690110773, 0.00013014224532525986, 0.00011144718155264854, 8.421106031164527e-05, 5.1707706006709486e-05, 1.7818869309849106e-05, -1.3450612641463522e-05, -3.8466670957859606e-05, -5.4408166761277243e-05, -5.960359703749418e-05, -5.372214945964515e-05, -3.7797602999489754e-05, -1.4084065696806647e-05, 1.4236529750633053e-05, 4.345730121713132e-05, 6.980883335927501e-05, 8.992338553071022e-05, 0.00010124392429133877, 0.00010232820204691961, 9.301200043410063e-05, 7.441309571731836e-05, 4.877753963228315e-05, 1.9189215890946798e-05, -1.0819974704645574e-05, -3.7710025935666636e-05, -5.836808850290254e-05, -7.048564293654636e-05, -7.283194281626493e-05, -6.539146124850959e-05, -4.935004108119756e-05, -2.6933674234896898e-05, -1.1213272728127777e-06, 2.4731001758482307e-05, 4.730774890049361e-05, 6.374084478011355e-05, 7.195647049229592e-05, 7.091963925631717e-05, 6.074785778764635e-05, 4.2681644117692485e-05, 1.891730607894715e-05, -7.675565029785503e-06, -3.3915657695615664e-05, -5.6705081078689545e-05, -7.340908632613719e-05, -8.217372669605538e-05, -8.214345143642277e-05, -7.355299749178812e-05, -5.768403207184747e-05, -3.669369107228704e-05, -1.3337763448362239e-05, 9.376047273690347e-06, 2.8561164072016254e-05, 4.1805324144661427e-05, 4.746067861560732e-05, 4.483610246097669e-05, 3.426919283811003e-05, 1.7070939065888524e-05, -4.648591584555106e-06, -2.8250391551409848e-05, -5.0898048357339576e-05, -6.990903057157993e-05, -8.308226824738085e-05, -8.896212966646999e-05, -8.700711623532698e-05, -7.764389010844752e-05, -6.220158684300259e-05, -4.273606464266777e-05, -2.1767242287751287e-05, -1.963034719665302e-06, 1.4190572073857766e-05, 2.4692499209777452e-05, 2.8265772925806232e-05, 2.4504375687683932e-05, 1.3911027053836733e-05, -2.177275746362284e-06, -2.176521775254514e-05, -4.245358650223352e-05, -6.173975998535752e-05, -7.732673111604527e-05, -8.740246994420886e-05, -9.085574129130691e-05, -8.740282646613196e-05, -7.761065353406593e-05, -6.281505920924246e-05, -4.494579479796812e-05, -2.6280911697540432e-05, -9.161917660094332e-06, 4.294845439289929e-06, 1.2455002433853224e-05, 1.4360043678607326e-05, 9.835378477873746e-06, -4.995179097022628e-07, -1.5318684745579958e-05, -3.276281859143637e-05, -5.067545862402767e-05, -6.68722641421482e-05, -7.940985233290121e-05, -8.682102634338662e-05, -8.828812860883772e-05, -8.37340485304594e-05, -7.382081093965098e-05, -5.9857451560674235e-05, -4.362966865301132e-05, -2.7173422495252453e-05, -1.2521142707555555e-05, -1.4520926470140694e-06, 4.722448011307279e-06, 5.31330579178757e-06, 3.288004961632396e-07, -9.536703146295622e-06, -2.2998370695859194e-05, -3.8347599911503494e-05, -5.3668311011279e-05, -6.70754598104395e-05, -7.694614760112017e-05, -8.211508975364268e-05, -8.201078890124336e-05, -7.671682396903634e-05, -6.695160118397325e-05, -5.3970488806953654e-05, -3.940337410313077e-05, -2.5048842871910892e-05, -1.265059836441651e-05, -3.684177272589295e-06, 8.201573677979468e-07, 3.970754107740504e-07, -4.805415755981812e-06, -1.40536722028628e-05, -2.6127641831408255e-05, -3.947830555262044e-05, -5.242308179731481e-05, -6.335462239803746e-05, -7.093703607097268e-05, -7.426577212754637e-05, -7.297193224076182e-05, -6.725912680849433e-05, -5.786952533526346e-05, -4.598411760525778e-05, -3.3070762583520263e-05, -2.0699369997601025e-05, -1.0347490388085134e-05, -3.2203367936745053e-06, -1.0716117060383112e-07, -1.2910204532090575e-06, -6.52217704555369e-06, -1.5057376003824174e-05, -2.5759116397239268e-05, -3.724175621755421e-05, -4.804570562555455e-05, -5.681790935341269e-05, -6.247627607081085e-05, -6.43381426925771e-05, -6.219760689418763e-05, -5.6342996685998514e-05, -4.751330925500952e-05, -3.680010559037328e-05, -2.5507622922305018e-05, -1.4989146620791871e-05, -6.4800224208738655e-06, -9.479629738962103e-07, 1.0212910410700715e-06, -7.105199983925559e-07, -5.824725576530909e-06, -1.3592553841590416e-05, -2.2971551516093314e-05, -3.273888069088571e-05, -4.1644561861176044e-05, -4.856538726016879e-05, -5.2640727517427877e-05, -5.337367838365026e-05, -5.068592508905567e-05, -4.492013977142051e-05, -3.679072324302979e-05, -2.7289677746011876e-05, -1.7560076230438426e-05, -8.75308433023747e-06, -1.8865472384277382e-06, 2.2776478090236196e-06, 3.3226108371309238e-06, 1.2215747346999706e-06, -3.6656820157077163e-06, -1.0643819223332684e-05, -1.877322756627109e-05, -2.698970820347313e-05, -3.423733141971752e-05, -3.959793320973404e-05, -4.240135967847891e-05, -4.230333070154302e-05, -3.9321850636042655e-05, -3.382852810318582e-05, -2.6496574719203636e-05, -1.8212753275292926e-05, -9.964663149730768e-06, -2.717712050070986e-06, 2.702968686207896e-06, 5.7112256399705075e-06, 6.0274333009147085e-06, 3.707175665113027e-06, -8.717665309632139e-07, -7.061743872327497e-06, -1.4029734302312136e-05, -2.0863040845142677e-05, -2.6682790121412836e-05, -3.075118729611859e-05, -3.255941192037426e-05, -3.188578921253793e-05, -2.8817572456318885e-05, -2.3734419301035814e-05, -1.7256257706321776e-05, -1.016265287034912e-05, -3.2941100016614655e-06, 2.5522354007989634e-06, 6.719591510773171e-06, 8.769401574681979e-06, 8.530937520845328e-06, 6.117065822763834e-06, 1.9048771946472698e-06, -3.5157315778633347e-06, -9.418606168765109e-06, -1.5033110685180873e-05, -1.9639568563434295e-05, -2.2656571672996506e-05, -2.3709581000730395e-05, -2.2672786144539714e-05, -1.9679611796163954e-05, -1.5101148164831102e-05, -9.495893209532369e-06, -3.537450766089023e-06, 2.0704203507193597e-06, 6.680759724986274e-06, 9.78162370302016e-06, 1.1056136827392038e-05, 1.0417385965411086e-05, 8.014369996089954e-06, 4.208859536447562e-06, -4.733671801204764e-07, -5.410424364526989e-06, -9.962610420188867e-06, -1.3551253687182907e-05, -1.5728424841654487e-05, -1.6229148968704976e-05, -1.5000055100244936e-05, -1.2201464414829388e-05, -8.18317766970722e-06, -3.4375580071355216e-06, 1.4639203982369509e-06, 5.942462848906871e-06, 9.483105714025442e-06, 1.1696504770952743e-05, 1.2363972928142175e-05, 1.1460596397228073e-05, 9.154059625871014e-06, 5.779869752586819e-06, 1.7965134020414553e-06, -2.273486643389333e-06, -5.9090762078994885e-06, -8.654543307784479e-06, -1.0173946066061035e-05, -1.0289639249094762e-05, -9.000497811939567e-06, -6.4780679167597555e-06, -3.041621539523476e-06, 8.843672389957646e-07, 4.824679763260065e-06, 8.312798854603898e-06, 1.0947925147775095e-05, 1.2442608749552164e-05, 1.2655381397053134e-05, 1.1604701285250485e-05, 9.46295949688647e-06, 6.531720373459393e-06, 3.2017042030929588e-06, -9.723611782419539e-08, -2.9497525702026905e-06, -5.005585535400314e-06, -6.0209486036910675e-06, -5.885854989173822e-06, -4.634361630451167e-06, -2.4368948743358487e-06, 4.239863926613907e-07, 3.5909852158511057e-06, 6.677723831671756e-06, 9.316846444562543e-06, 1.1204589100088924e-05, 1.2136451914557256e-05, 1.2029784556943923e-05, 1.0930856660706922e-05, 9.005929314298555e-06, 6.517822839668952e-06, 3.791232074945583e-06, 1.171328108284797e-06, -1.0190830153078423e-06, -2.5185556751239346e-06, -3.1574586500937585e-06, -2.876363396353554e-06, -1.7304292896369589e-06, 1.2039534169616672e-07, 2.433773033772013e-06, 4.916894340567524e-06, 7.263740826601861e-06, 9.192965080728754e-06, 1.0481724530109204e-05, 1.0991414455929771e-05, 1.068235815182561e-05, 9.615951057639904e-06, 7.944340723042842e-06, 5.889248768653488e-06, 3.712839543368318e-06, 1.6844476249389118e-06, 4.735241532216605e-08, -1.0103000249728211e-06, -1.3769825955023407e-06, -1.0292475280948565e-06, -3.204360865538547e-08, 1.471831524213485e-06, 3.281529643572867e-06, 5.164498816156993e-06, 6.8859453676850535e-06, 8.237699148594402e-06, 9.0629455371527e-06, 9.273909199691843e-06, 8.860520210873801e-06, 7.889276275818702e-06, 6.492734428320546e-06, 4.851206540479325e-06, 3.1691631647845497e-06, 1.6494003602929297e-06, 4.682254655108409e-07, -2.4531701114938187e-07, -4.2375216935397475e-07, -6.745563752019734e-08, 7.576058465019742e-07, 1.930122380144894e-06, 3.2901548365771305e-06, 4.660048034565989e-06, 5.866824722033925e-06, 6.763255896657938e-06, 7.245057531690691e-06, 7.262219696713146e-06, 6.82327163303853e-06, 5.9922067521256395e-06, 4.878683739661938e-06, 3.6229555462341523e-06, 2.377568762312876e-06, 1.28819908695732e-06, 4.7601869823665766e-07, 2.372009078044357e-08, -3.3214583083918114e-08, 2.908910232690687e-07, 9.355410384159768e-07, 1.8032529851552681e-06]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>rx_af_post</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0_0_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_1_1</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_1_1</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_2_3</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_2_6</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0_0_1</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_2_5</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_bpf_2_7</value></param>
<param><key>nthreads</key><value>2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>RX</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate*2</value></param>
<param><key>baseband_freq</key><value>freq-0.068+2400</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>-60</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>rx_rf1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RF-S','RF-W', 'CHAN', 'AUDIO','AUDIO','AUDIO']</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>rx_rf</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>rx_af1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_2_0</value></param>
<param><key>stream_id</key><value>rx_af_post</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RF Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate*2</value></param>
<param><key>baseband_freq</key><value>freq-0.068+2400</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.3</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>USRP</value></param>
<param><key>value</key><value>band</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ant</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>value</key><value>'RX2'</value></param>
<param><key>choices</key><value>['TX/RX', 'RX2']</value></param>
<param><key>labels</key><value>['TX/RX','RX2']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>agc_level</value></param>
<param><key>label</key><value>AGC Level</value></param>
<param><key>value</key><value>.00025</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>agc_gain</value></param>
<param><key>label</key><value>AGC Gain</value></param>
<param><key>value</key><value>.25</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>agc_atk</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>AGC Attack</value></param>
<param><key>value</key><value>3.25e-4</value></param>
<param><key>min</key><value>-1</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>agc_decay</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>AGC decay</value></param>
<param><key>value</key><value>1.0E-5</value></param>
<param><key>min</key><value>-1</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF GAIN</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>72</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>on_off</value></param>
<param><key>label</key><value>Power</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[1, 0]</value></param>
<param><key>labels</key><value>['On','Off']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>period</value></param>
<param><key>label</key><value>Period</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mag</value></param>
<param><key>label</key><value>Magintude</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>Phase</value></param>
<param><key>value</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>360</value></param>
<param><key>num_steps</key><value>360</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
</block>
<block>
<key>variable_baz_static_text</key>
<param><key>id</key><value>variable_baz_static_text_0</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>freq+(offset_coarse + offset_fine)</value></param>
<param><key>font_size</key><value>40</value></param>
<param><key>bold</key><value>True</value></param>
<param><key>colour</key><value>wx.RED</value></param>
<param><key>size</key><value>(-1, -1)</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>VOL</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rail_lo</value></param>
<param><key>label</key><value>Rail Low Level</value></param>
<param><key>value</key><value>-.99</value></param>
<param><key>min</key><value>-1</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rail_hi</value></param>
<param><key>label</key><value>Rail High Level</value></param>
<param><key>value</key><value>.99</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>nb1,2</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>af_width</value></param>
<param><key>label</key><value>Filter Width</value></param>
<param><key>value</key><value>4</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6]</value></param>
<param><key>labels</key><value>['1.1k','1.7k','2.3k','2.6k','2.7k','2.5k','All']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>nb1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delay_1</value></param>
<param><key>label</key><value>Delay 2</value></param>
<param><key>value</key><value>505</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>16</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>nb1,2</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>usb_lsb</value></param>
<param><key>label</key><value>Sideband</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[1, 0]</value></param>
<param><key>labels</key><value>['USB','LSB']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>nb1,1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb1</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RF','Mode', 'Audio','VFO']</value></param>
<param><key>grid_pos</key><value>0,0,1,18</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-2000</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>800</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,2</value></param>
<param><key>notebook</key><value>nb1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-240000</value></param>
<param><key>max</key><value>240000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,2</value></param>
<param><key>notebook</key><value>nb1,3</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Audio Non Filtered - Frequency Domain</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>2</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-74</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>.133</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>400,100</value></param>
<param><key>notebook</key><value>nb,5</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Audio Frequency - Frequency Domain</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>2</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-40</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>80</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>notebook</key><value>nb,4</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Audio Frequency - Time Domain</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb,3</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel Spectrum</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>freq+(offset_coarse + offset_fine)</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-70</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>120</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.133</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>band</value></param>
<param><key>label</key><value>Select Band</value></param>
<param><key>value</key><value>3750000</value></param>
<param><key>choices</key><value>[52000000,29000000,24940000,21250000,18118000,14175000,10125000,7175000,5357000,3750000,1900000,2500000,5000000,10000000,15000000,20000000]</value></param>
<param><key>labels</key><value>['6 Meters','10 Meters','12 Meters','15 Meters','17 Meters','20 Meters','30 Meters','40 Meters','60 Meters','80 Meters','160 Meters','WWV-2.5 Mhz','WWV-5 Mhz','WWV-10 Mhz','WWV-15 Mhz','WWV-20 Mhz']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,4,1,2</value></param>
<param><key>notebook</key><value>nb1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mic_gain</value></param>
<param><key>label</key><value>TX MIC GAIN</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>nb1,1</value></param>
</block>
<block>
<key>lsb_weaver_modulator</key>
<param><key>id</key><value>lsb_weaver_modulator_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>usb_weaver_modulator</key>
<param><key>id</key><value>usb_weaver_modulator_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>10**(1.*mic_gain/10)</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_0</value></param>
<param><key>lo</key><value>rail_lo</value></param>
<param><key>hi</key><value>rail_hi</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>TX</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>ok_to_block</key><value>False</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>int(samp_rate/1000)</value></param>
<param><key>decim</key><value>audio_rate/1000</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>usb_lsb</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>usb_lsb</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>~usb_lsb+2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate*2</value></param>
<param><key>low_cutoff_freq</key><value>300</value></param>
<param><key>high_cutoff_freq</key><value>3000</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
<param><key>beta</key><value>6.76</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.05</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
<param><key>seed</key><value>1131973</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>BaseBand</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>rx_rf1</value></param>
</block>
<block>
<key>iqbalance_fix_cc</key>
<param><key>id</key><value>iqbalance_fix_cc_0</value></param>
<param><key>mag</key><value>mag</value></param>
<param><key>phase</key><value>phase</value></param>
</block>
<block>
<key>iqbalance_optimize_c</key>
<param><key>id</key><value>iqbalance_optimize_c_0</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>6.25E-4</value></param>
<param><key>decay_rate</key><value>1e-5</value></param>
<param><key>reference</key><value>agc_level</value></param>
<param><key>gain</key><value>agc_gain</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>(offset_coarse + offset_fine)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>rx_rf</value></param>
</block>
<block>
<key>bhj_lms_equalizer_cc</key>
<param><key>id</key><value>bhj_lms_equalizer_cc</value></param>
<param><key>mu</key><value>mu_1</value></param>
<param><key>num_taps</key><value>taps/4</value></param>
<param><key>decimation</key><value>1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>int(audio_rate/1000)</value></param>
<param><key>decim</key><value>int(samp_rate/1000)</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_3_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_lpf</value></param>
<param><key>nthreads</key><value>4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>rx_af_post</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rx_rf</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>usb_lsb</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>open</key><value>~usb_lsb+2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>usb_lsb</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>usb_weaver_modulator</key>
<param><key>id</key><value>usb_weaver_modulator_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>bhj_lms_equalizer_cc</key>
<param><key>id</key><value>bhj_lms_equalizer_cc_0</value></param>
<param><key>mu</key><value>mu_1/12</value></param>
<param><key>num_taps</key><value>int(taps/4)</value></param>
<param><key>decimation</key><value>1</value></param>
</block>
<block>
<key>bhj_lms_equalizer_cc</key>
<param><key>id</key><value>bhj_lms_equalizer_cc_0_0_0</value></param>
<param><key>mu</key><value>mu_1/48</value></param>
<param><key>num_taps</key><value>int(taps*1)</value></param>
<param><key>decimation</key><value>1</value></param>
</block>
<block>
<key>bhj_lms_equalizer_cc</key>
<param><key>id</key><value>bhj_lms_equalizer_cc_0_0</value></param>
<param><key>mu</key><value>mu_1/24</value></param>
<param><key>num_taps</key><value>int(taps/2)</value></param>
<param><key>decimation</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>int(delay_1)</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>lo</key><value>rail_lo</value></param>
<param><key>hi</key><value>rail_hi</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>10**(1.*af_gain/10)</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>rx_af1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>7</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>af_width</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>7</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>af_width</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Update the path to a wav file you want to use</value></param>
</block>
<block>
<key>lsb_weaver_modulator</key>
<param><key>id</key><value>lsb_weaver_modulator_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>ssb_rxtx</value></param>
<param><key>title</key><value>SSB Weaver</value></param>
<param><key>author</key><value>Brock Judd N5WSS</value></param>
<param><key>description</key><value>Upper and Lower Single Sideband Suppressed Carrier</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run</key><value>bool(on_off)</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/brock/gnuradio-sdr/N5WSS-Testing123.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_2_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_3_0</source_block_id><sink_block_id>bhj_lms_equalizer_cc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iqbalance_optimize_c_0</source_block_id><sink_block_id>iqbalance_fix_cc_0</sink_block_id><source_key>iqbal_corr</source_key><sink_key>iqbal_corr</sink_key></connection>
<connection><source_block_id>iqbalance_fix_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bhj_lms_equalizer_cc</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bhj_lms_equalizer_cc_0_0</source_block_id><sink_block_id>bhj_lms_equalizer_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bhj_lms_equalizer_cc_0</source_block_id><sink_block_id>bhj_lms_equalizer_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blks2_selector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1_0_0_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>bhj_lms_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blks2_selector_1_0</source_block_id><sink_block_id>fft_filter_xxx_1_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>iqbalance_fix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>iqbalance_optimize_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>usb_weaver_modulator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>lsb_weaver_modulator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsb_weaver_modulator_0_0</source_block_id><sink_block_id>blks2_valve_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usb_weaver_modulator_0_0</source_block_id><sink_block_id>blks2_valve_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>analog_rail_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_0</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_0_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsb_weaver_modulator_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usb_weaver_modulator_0</source_block_id><sink_block_id>blks2_valve_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>lsb_weaver_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>usb_weaver_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bhj_lms_equalizer_cc_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
